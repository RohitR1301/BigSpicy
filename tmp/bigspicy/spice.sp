** SPICE netlist generated by bigspicy.py at Fri Dec  9 11:19:54 2022 UTC
.SUBCKT iiitb_brg
+ VGND VPWR clk clkout reset sel.0 sel.1
** replacing ANTENNA_1 with the contents of sky130_fd_sc_hd__diode_2

** replacing FILLER_0_103 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_103_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_103_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_0_111 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_0_113 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_113_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_113_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_0_121 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_0_138 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_0_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_0_16 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_16/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_16/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_16/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_16/VPB =>[signal: VPWR w=1]]']]
FILLER_0_16 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_0_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_29/VPB =>[signal: VPWR w=1]]']]
FILLER_0_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_3 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_0_41 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_0_52 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_52_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_52_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_0_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_57/VPB =>[signal: VPWR w=1]]']]
FILLER_0_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_0_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_69/VPB =>[signal: VPWR w=1]]']]
FILLER_0_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_7 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_0_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_0_85 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_10_105 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_10_120 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_120_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_120_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_10_128 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_128_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_128_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_10_138 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_10_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_10_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_15/VPB =>[signal: VPWR w=1]]']]
FILLER_10_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_10_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_29/VPB =>[signal: VPWR w=1]]']]
FILLER_10_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_3/VPB =>[signal: VPWR w=1]]']]
FILLER_10_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_41/VPB =>[signal: VPWR w=1]]']]
FILLER_10_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_53 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_10_64 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_64/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_64/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_64/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_64/VPB =>[signal: VPWR w=1]]']]
FILLER_10_64 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_76 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_76_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_76_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_10_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_85/VPB =>[signal: VPWR w=1]]']]
FILLER_10_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_97 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_11_106 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_106_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_106_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_11_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_113/VPB =>[signal: VPWR w=1]]']]
FILLER_11_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_125 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_11_143 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_11_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_15/VPB =>[signal: VPWR w=1]]']]
FILLER_11_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_27/VPB =>[signal: VPWR w=1]]']]
FILLER_11_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_3/VPB =>[signal: VPWR w=1]]']]
FILLER_11_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_39/VPB =>[signal: VPWR w=1]]']]
FILLER_11_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_11_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_11_57 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_11_82 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_82/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_82/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_82/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_82/VPB =>[signal: VPWR w=1]]']]
FILLER_11_82 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_94 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_94/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_94/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_94/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_94/VPB =>[signal: VPWR w=1]]']]
FILLER_11_94 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_103 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_103/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_103/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_103/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_103/VPB =>[signal: VPWR w=1]]']]
FILLER_12_103 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_115 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_115/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_115/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_115/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_115/VPB =>[signal: VPWR w=1]]']]
FILLER_12_115 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_127 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_127/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_127/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_127/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_127/VPB =>[signal: VPWR w=1]]']]
FILLER_12_127 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_139 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_12_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_12_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_15/VPB =>[signal: VPWR w=1]]']]
FILLER_12_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_29/VPB =>[signal: VPWR w=1]]']]
FILLER_12_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_3/VPB =>[signal: VPWR w=1]]']]
FILLER_12_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_41/VPB =>[signal: VPWR w=1]]']]
FILLER_12_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_58 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_58_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_58_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_12_82 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_12_85 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_12_91 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_91/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_91/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_91/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_91/VPB =>[signal: VPWR w=1]]']]
FILLER_12_91 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_13_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_13_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_113/VPB =>[signal: VPWR w=1]]']]
FILLER_13_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_125/VPB =>[signal: VPWR w=1]]']]
FILLER_13_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_137 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_13_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_15/VPB =>[signal: VPWR w=1]]']]
FILLER_13_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_27/VPB =>[signal: VPWR w=1]]']]
FILLER_13_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_3/VPB =>[signal: VPWR w=1]]']]
FILLER_13_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_39/VPB =>[signal: VPWR w=1]]']]
FILLER_13_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_13_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_13_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_57/VPB =>[signal: VPWR w=1]]']]
FILLER_13_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_69/VPB =>[signal: VPWR w=1]]']]
FILLER_13_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_81/VPB =>[signal: VPWR w=1]]']]
FILLER_13_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_93/VPB =>[signal: VPWR w=1]]']]
FILLER_13_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_104 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_104/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_104/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_104/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_104/VPB =>[signal: VPWR w=1]]']]
FILLER_14_104 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_116 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_116/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_116/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_116/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_116/VPB =>[signal: VPWR w=1]]']]
FILLER_14_116 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_128 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_128/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_128/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_128/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_128/VPB =>[signal: VPWR w=1]]']]
FILLER_14_128 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_14_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_15/VPB =>[signal: VPWR w=1]]']]
FILLER_14_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_14_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_29/VPB =>[signal: VPWR w=1]]']]
FILLER_14_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_3/VPB =>[signal: VPWR w=1]]']]
FILLER_14_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_41 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_14_65 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_14_73 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_14_80 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_80_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_80_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_14_85 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_14_92 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_92/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_92/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_92/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_92/VPB =>[signal: VPWR w=1]]']]
FILLER_14_92 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_104 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_104_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_104_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_15_113 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_15_123 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_123/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_123/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_123/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_123/VPB =>[signal: VPWR w=1]]']]
FILLER_15_123 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_135 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_135_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_135_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_15_143 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_15_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_15/VPB =>[signal: VPWR w=1]]']]
FILLER_15_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_27/VPB =>[signal: VPWR w=1]]']]
FILLER_15_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_3/VPB =>[signal: VPWR w=1]]']]
FILLER_15_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_39/VPB =>[signal: VPWR w=1]]']]
FILLER_15_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_15_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_15_57 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_15_63 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_15_68 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_68_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_68_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_15_78 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_78_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_78_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_15_92 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_92/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_92/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_92/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_92/VPB =>[signal: VPWR w=1]]']]
FILLER_15_92 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_109/VPB =>[signal: VPWR w=1]]']]
FILLER_16_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_121/VPB =>[signal: VPWR w=1]]']]
FILLER_16_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_13 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_13/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_13/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_13/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_13/VPB =>[signal: VPWR w=1]]']]
FILLER_16_13 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_133 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_16_138 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_16_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_16_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_16_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_29/VPB =>[signal: VPWR w=1]]']]
FILLER_16_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_16_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_57/VPB =>[signal: VPWR w=1]]']]
FILLER_16_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_69/VPB =>[signal: VPWR w=1]]']]
FILLER_16_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_16_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_85/VPB =>[signal: VPWR w=1]]']]
FILLER_16_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_97/VPB =>[signal: VPWR w=1]]']]
FILLER_16_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_17_111 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_17_113 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_17_132 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_132/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_132/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_132/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_132/VPB =>[signal: VPWR w=1]]']]
FILLER_17_132 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_144 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_17_23 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_23/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_23/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_23/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_23/VPB =>[signal: VPWR w=1]]']]
FILLER_17_23 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_3/VPB =>[signal: VPWR w=1]]']]
FILLER_17_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_35 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_35/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_35/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_35/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_35/VPB =>[signal: VPWR w=1]]']]
FILLER_17_35 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_47 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_47_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_47_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_17_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_17_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_57/VPB =>[signal: VPWR w=1]]']]
FILLER_17_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_69/VPB =>[signal: VPWR w=1]]']]
FILLER_17_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_81/VPB =>[signal: VPWR w=1]]']]
FILLER_17_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_93/VPB =>[signal: VPWR w=1]]']]
FILLER_17_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_106 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_106/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_106/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_106/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_106/VPB =>[signal: VPWR w=1]]']]
FILLER_18_106 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_118 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_118/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_118/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_118/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_118/VPB =>[signal: VPWR w=1]]']]
FILLER_18_118 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_18_130 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_130_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_130_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_18_138 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_18_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_18_21 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_18_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_18_29 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_18_3 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_18_53 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_18_61 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_18_67 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_67_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_67_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_18_74 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_74_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_74_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_18_82 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_18_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_85/VPB =>[signal: VPWR w=1]]']]
FILLER_18_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_18_97 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_97_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_97_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_19_100 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_100/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_100/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_100/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_100/VPB =>[signal: VPWR w=1]]']]
FILLER_19_100 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_113/VPB =>[signal: VPWR w=1]]']]
FILLER_19_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_125/VPB =>[signal: VPWR w=1]]']]
FILLER_19_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_19_137 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_19_15 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_19_24 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_24/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_24/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_24/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_24/VPB =>[signal: VPWR w=1]]']]
FILLER_19_24 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_3/VPB =>[signal: VPWR w=1]]']]
FILLER_19_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_36 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_36/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_36/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_36/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_36/VPB =>[signal: VPWR w=1]]']]
FILLER_19_36 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_19_48 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_48_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_48_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_19_57 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_19_75 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_75_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_75_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_19_86 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_86_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_86_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_19_93 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_93_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_93_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_1_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_113/VPB =>[signal: VPWR w=1]]']]
FILLER_1_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_125 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_125_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_125_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_132 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_132_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_132_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_142 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_142_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_142_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_1_21 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_1_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_27/VPB =>[signal: VPWR w=1]]']]
FILLER_1_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_1_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_39/VPB =>[signal: VPWR w=1]]']]
FILLER_1_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_1_57 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_1_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_1_74 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_74/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_74/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_74/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_74/VPB =>[signal: VPWR w=1]]']]
FILLER_1_74 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_86 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_86_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_86_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_1_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_9/VPB =>[signal: VPWR w=1]]']]
FILLER_1_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_90 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_1_99 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_99/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_99/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_99/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_99/VPB =>[signal: VPWR w=1]]']]
FILLER_1_99 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_109 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_109_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_109_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_20_119 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_119_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_119_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_20_127 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_127_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_127_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_20_137 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_20_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_20_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_15/VPB =>[signal: VPWR w=1]]']]
FILLER_20_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_20_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_29/VPB =>[signal: VPWR w=1]]']]
FILLER_20_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_3/VPB =>[signal: VPWR w=1]]']]
FILLER_20_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_41 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_20_45 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_45/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_45/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_45/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_45/VPB =>[signal: VPWR w=1]]']]
FILLER_20_45 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_57 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_20_64 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_64/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_64/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_64/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_64/VPB =>[signal: VPWR w=1]]']]
FILLER_20_64 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_76 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_76_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_76_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_20_85 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_20_95 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_95_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_95_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_21_111 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_21_113 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_21_124 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_124/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_124/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_124/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_124/VPB =>[signal: VPWR w=1]]']]
FILLER_21_124 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_136 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_136_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_136_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_21_144 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_21_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_15/VPB =>[signal: VPWR w=1]]']]
FILLER_21_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_27/VPB =>[signal: VPWR w=1]]']]
FILLER_21_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_3/VPB =>[signal: VPWR w=1]]']]
FILLER_21_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_39/VPB =>[signal: VPWR w=1]]']]
FILLER_21_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_21_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_21_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_57/VPB =>[signal: VPWR w=1]]']]
FILLER_21_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_69 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_69_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_69_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_21_73 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_21_82 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_82_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_82_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_21_99 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_99/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_99/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_99/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_99/VPB =>[signal: VPWR w=1]]']]
FILLER_21_99 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_102 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_102_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_102_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_22_114 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_114_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_114_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_22_135 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_135_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_135_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_22_139 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_22_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_22_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_15/VPB =>[signal: VPWR w=1]]']]
FILLER_22_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_22_29 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_22_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_3/VPB =>[signal: VPWR w=1]]']]
FILLER_22_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_35 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_35/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_35/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_35/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_35/VPB =>[signal: VPWR w=1]]']]
FILLER_22_35 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_47 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_47/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_47/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_47/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_47/VPB =>[signal: VPWR w=1]]']]
FILLER_22_47 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_66 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_66/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_66/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_66/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_66/VPB =>[signal: VPWR w=1]]']]
FILLER_22_66 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_78 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_78_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_78_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_22_85 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_22_90 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_90/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_90/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_90/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_90/VPB =>[signal: VPWR w=1]]']]
FILLER_22_90 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_23_111 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_23_113 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_23_132 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_132/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_132/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_132/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_132/VPB =>[signal: VPWR w=1]]']]
FILLER_23_132 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_144 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_23_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_15/VPB =>[signal: VPWR w=1]]']]
FILLER_23_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_27 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_23_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_3/VPB =>[signal: VPWR w=1]]']]
FILLER_23_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_33 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_33/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_33/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_33/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_33/VPB =>[signal: VPWR w=1]]']]
FILLER_23_33 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_45 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_45_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_45_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_23_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_23_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_57/VPB =>[signal: VPWR w=1]]']]
FILLER_23_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_69/VPB =>[signal: VPWR w=1]]']]
FILLER_23_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_81/VPB =>[signal: VPWR w=1]]']]
FILLER_23_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_93/VPB =>[signal: VPWR w=1]]']]
FILLER_23_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_102 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_102_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_102_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_24_110 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_24_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_113/VPB =>[signal: VPWR w=1]]']]
FILLER_24_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_125/VPB =>[signal: VPWR w=1]]']]
FILLER_24_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_137 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_24_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_24_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_15/VPB =>[signal: VPWR w=1]]']]
FILLER_24_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_24_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_29/VPB =>[signal: VPWR w=1]]']]
FILLER_24_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_3/VPB =>[signal: VPWR w=1]]']]
FILLER_24_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_41/VPB =>[signal: VPWR w=1]]']]
FILLER_24_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_24_57 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_24_63 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_24_70 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_70/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_70/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_70/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_70/VPB =>[signal: VPWR w=1]]']]
FILLER_24_70 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_82 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_24_85 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_24_90 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_90/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_90/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_90/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_90/VPB =>[signal: VPWR w=1]]']]
FILLER_24_90 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_103 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_103/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_103/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_103/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_103/VPB =>[signal: VPWR w=1]]']]
FILLER_2_103 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_115 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_115_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_115_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_2_123 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_123_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_123_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_2_134 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_134_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_134_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_2_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_2_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_15/VPB =>[signal: VPWR w=1]]']]
FILLER_2_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_2_29 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_2_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_3/VPB =>[signal: VPWR w=1]]']]
FILLER_2_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_35 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_43 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_43/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_43/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_43/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_43/VPB =>[signal: VPWR w=1]]']]
FILLER_2_43 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_55 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_55/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_55/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_55/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_55/VPB =>[signal: VPWR w=1]]']]
FILLER_2_55 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_67 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_67/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_67/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_67/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_67/VPB =>[signal: VPWR w=1]]']]
FILLER_2_67 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_79 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_79_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_79_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_2_83 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_2_85 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_3_104 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_3_109 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_109_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_109_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_3_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_113/VPB =>[signal: VPWR w=1]]']]
FILLER_3_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_125/VPB =>[signal: VPWR w=1]]']]
FILLER_3_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_142 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_142_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_142_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_3_20 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_3_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_3_32 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_32/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_32/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_32/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_32/VPB =>[signal: VPWR w=1]]']]
FILLER_3_32 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_44 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_44/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_44/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_44/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_44/VPB =>[signal: VPWR w=1]]']]
FILLER_3_44 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_57 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_3_68 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_68_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_68_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_3_77 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_3_8 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_8/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_8/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_8/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_8/VPB =>[signal: VPWR w=1]]']]
FILLER_3_8 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_85 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_3_96 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_96_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_96_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_4_102 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_102/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_102/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_102/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_102/VPB =>[signal: VPWR w=1]]']]
FILLER_4_102 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_114 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_114_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_114_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_4_122 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_122_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_122_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_4_129 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_129_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_129_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_4_137 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_4_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_4_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_15/VPB =>[signal: VPWR w=1]]']]
FILLER_4_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_4_29 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_4_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_3/VPB =>[signal: VPWR w=1]]']]
FILLER_4_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_38 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_38/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_38/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_38/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_38/VPB =>[signal: VPWR w=1]]']]
FILLER_4_38 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_50 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_50_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_50_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_4_58 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_4_76 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_76_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_76_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_4_85 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_4_90 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_90/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_90/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_90/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_90/VPB =>[signal: VPWR w=1]]']]
FILLER_4_90 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_100 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_100/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_100/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_100/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_100/VPB =>[signal: VPWR w=1]]']]
FILLER_5_100 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_113 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_5_132 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_132/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_132/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_132/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_132/VPB =>[signal: VPWR w=1]]']]
FILLER_5_132 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_14 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_5_144 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_5_18 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_18/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_18/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_18/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_18/VPB =>[signal: VPWR w=1]]']]
FILLER_5_18 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_5_30 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_30/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_30/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_30/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_30/VPB =>[signal: VPWR w=1]]']]
FILLER_5_30 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_42 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_42/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_42/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_42/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_42/VPB =>[signal: VPWR w=1]]']]
FILLER_5_42 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_54 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_5_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_57/VPB =>[signal: VPWR w=1]]']]
FILLER_5_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_69 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_69_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_69_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_5_93 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_93_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_93_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_6_10 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_10/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_10/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_10/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_10/VPB =>[signal: VPWR w=1]]']]
FILLER_6_10 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_104 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_104/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_104/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_104/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_104/VPB =>[signal: VPWR w=1]]']]
FILLER_6_104 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_116 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_116/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_116/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_116/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_116/VPB =>[signal: VPWR w=1]]']]
FILLER_6_116 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_128 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_128/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_128/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_128/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_128/VPB =>[signal: VPWR w=1]]']]
FILLER_6_128 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_6_22 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_6_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_29/VPB =>[signal: VPWR w=1]]']]
FILLER_6_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_3 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_6_41 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_6_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_57/VPB =>[signal: VPWR w=1]]']]
FILLER_6_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_69/VPB =>[signal: VPWR w=1]]']]
FILLER_6_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_6_85 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_6_94 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_94_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_94_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_108 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_108_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_108_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_113 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_113_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_113_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_7_130 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_130_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_130_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_7_143 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_7_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_15/VPB =>[signal: VPWR w=1]]']]
FILLER_7_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_27/VPB =>[signal: VPWR w=1]]']]
FILLER_7_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_3/VPB =>[signal: VPWR w=1]]']]
FILLER_7_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_39/VPB =>[signal: VPWR w=1]]']]
FILLER_7_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_7_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_7_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_57/VPB =>[signal: VPWR w=1]]']]
FILLER_7_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_69/VPB =>[signal: VPWR w=1]]']]
FILLER_7_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_81/VPB =>[signal: VPWR w=1]]']]
FILLER_7_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_96 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_96/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_96/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_96/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_96/VPB =>[signal: VPWR w=1]]']]
FILLER_7_96 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_104 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_104/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_104/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_104/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_104/VPB =>[signal: VPWR w=1]]']]
FILLER_8_104 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_116 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_116/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_116/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_116/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_116/VPB =>[signal: VPWR w=1]]']]
FILLER_8_116 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_128 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_128/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_128/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_128/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_128/VPB =>[signal: VPWR w=1]]']]
FILLER_8_128 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_141 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_8_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_15/VPB =>[signal: VPWR w=1]]']]
FILLER_8_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_8_29 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_8_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_3/VPB =>[signal: VPWR w=1]]']]
FILLER_8_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_8_58 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_58/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_58/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_58/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_58/VPB =>[signal: VPWR w=1]]']]
FILLER_8_58 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_70 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_70/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_70/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_70/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_70/VPB =>[signal: VPWR w=1]]']]
FILLER_8_70 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_82 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_8_85 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_8_92 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_92/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_92/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_92/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_92/VPB =>[signal: VPWR w=1]]']]
FILLER_8_92 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_101 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_101_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_101_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_9_105 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_9_109 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_109_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_109_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_9_113 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_9_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_121/VPB =>[signal: VPWR w=1]]']]
FILLER_9_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_133 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_9_142 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_142_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_142_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_9_15 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_9_19 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_9_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_3/VPB =>[signal: VPWR w=1]]']]
FILLER_9_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_36 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_36/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_36/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_36/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_36/VPB =>[signal: VPWR w=1]]']]
FILLER_9_36 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_48 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_48_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_48_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_9_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_57/VPB =>[signal: VPWR w=1]]']]
FILLER_9_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_69 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_69_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_69_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_9_73 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_9_82 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_82_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_82_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_9_88 with the contents of sky130_fd_sc_hd__fill_1

** replacing PHY_0 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_0_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_0_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_1 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_1_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_1_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_10 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_10_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_10_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_11 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_11_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_11_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_12 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_12_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_12_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_13 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_13_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_13_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_14 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_14_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_14_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_15 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_16 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_16_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_16_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_17 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_17_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_17_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_18 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_18_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_18_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_19 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_19_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_19_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_2 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_2_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_2_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_20 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_21 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_22 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_23 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_23_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_23_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_24 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_24_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_24_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_26 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_26_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_26_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_27 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_28 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_28_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_28_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_29 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_30 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_30_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_30_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_31 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_31_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_31_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_32 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_32_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_32_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_33 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_33_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_33_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_34 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_35 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_35_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_35_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_36 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_36_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_36_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_37 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_37_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_37_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_38 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_38_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_38_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_39 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_39_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_39_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_4 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_4_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_4_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_40 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_40_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_40_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_41 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_42 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_42_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_42_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_43 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_43_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_43_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_44 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_44_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_44_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_45 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_45_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_45_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_46 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_46_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_46_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_47 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_47_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_47_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_48 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_48_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_48_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_49 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_49_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_49_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_5 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_5_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_5_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_6 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_6_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_6_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_7 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_7_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_7_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_8 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_8_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_8_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_9 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing TAP_100 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_101 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_102 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_103 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_104 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_105 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_106 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_107 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_108 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_109 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_110 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_111 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_112 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_113 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_114 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_115 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_116 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_50 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_51 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_52 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_53 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_54 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_55 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_56 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_57 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_58 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_59 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_60 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_61 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_62 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_63 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_64 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_65 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_66 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_67 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_68 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_69 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_70 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_71 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_72 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_73 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_74 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_75 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_76 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_77 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_78 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_79 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_80 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_81 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_82 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_83 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_84 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_85 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_86 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_87 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_88 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_89 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_90 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_91 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_92 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_93 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_94 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_95 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_96 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_97 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_98 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_99 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing _073_ with the contents of sky130_fd_sc_hd__nor4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: Y w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__073__0 VGND _026_ _042_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_191_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_297_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__073__1 _073__a_191_297# _026_ _073__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_297_297# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__073__2 _073__a_297_297# _034_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: C w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__073__3 _042_ _033_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: D w=1]]', 's: [connection X4/s =>[signal: Y w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__073__4 VGND _038_ _042_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_109_297# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: a_191_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__073__5 _073__a_109_297# _033_ _073__a_191_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: Y w=1]]', 'g: [connection X6/g =>[signal: D w=1]]', 's: [connection X6/s =>[signal: a_109_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__073__6 _042_ _038_ _073__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: Y w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__073__7 _042_ _034_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _074_ with the contents of sky130_fd_sc_hd__or3_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_29_53# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__074__0 VPWR _074__a_29_53# _043_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_111_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_183_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__074__1 _074__a_111_297# _035_ _074__a_183_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_29_53# w=1]]', 'g: [connection X2/g =>[signal: C w=1]]', 's: [connection X2/s =>[signal: a_111_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__074__2 _074__a_29_53# cnt2[1] _074__a_111_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_29_53# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__074__3 VGND _074__a_29_53# _043_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_29_53# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__074__4 _074__a_29_53# cnt2[1] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_29_53# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__074__5 _074__a_29_53# _022_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_183_297# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__074__6 _074__a_183_297# _022_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: a_29_53# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__074__7 VGND _035_ _074__a_29_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _075_ with the contents of sky130_fd_sc_hd__o31a_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_253_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__075__0 _075__a_253_47# _033_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_253_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__075__1 VPWR _026_ _075__a_253_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_103_199# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__075__2 _044_ _075__a_103_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_103_199# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__075__3 _044_ _075__a_103_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_253_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__075__4 VGND _026_ _075__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_103_199# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__075__5 _075__a_103_199# _034_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_253_47# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_103_199# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__075__6 _075__a_253_47# _034_ _075__a_103_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_253_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__075__7 VGND _043_ _075__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_253_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_337_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__075__8 _075__a_253_297# _033_ _075__a_337_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_337_297# w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_103_199# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__075__9 _075__a_337_297# _043_ _075__a_103_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _076_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__076__0 _076__a_109_297# _042_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__076__1 _001_ _042_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__076__2 VGND _044_ _001_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__076__3 _001_ _044_ _076__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _077_ with the contents of sky130_fd_sc_hd__or4b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_109_53# w=1]]', 's: [connection X0/s =>[signal: a_215_297# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__077__0 VGND _077__a_109_53# _077__a_215_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_215_297# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__077__1 _077__a_215_297# _026_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_215_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__077__2 VGND _033_ _077__a_215_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_297_297# w=1]]', 'g: [connection X3/g =>[signal: C w=1]]', 's: [connection X3/s =>[signal: a_392_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__077__3 _077__a_297_297# _038_ _077__a_392_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_215_297# w=1]]', 'g: [connection X4/g =>[signal: a_109_53# w=1]]', 's: [connection X4/s =>[signal: a_297_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__077__4 _077__a_215_297# _077__a_109_53# _077__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_392_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_465_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__077__5 _077__a_392_297# _033_ _077__a_465_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_215_297# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__077__6 VGND _077__a_215_297# _045_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: D_N w=1]]', 's: [connection X7/s =>[signal: a_109_53# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__077__7 VGND _043_ _077__a_109_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_215_297# w=1]]', 'g: [connection X8/g =>[signal: C w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__077__8 _077__a_215_297# _038_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: D_N w=1]]', 's: [connection X9/s =>[signal: a_109_53# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__077__9 VPWR _043_ _077__a_109_53# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_465_297# w=1]]', 'g: [connection X10/g =>[signal: A w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__077__10 _077__a_465_297# _026_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_215_297# w=1]]', 's: [connection X11/s =>[signal: X w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__077__11 VPWR _077__a_215_297# _045_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _078_ with the contents of sky130_fd_sc_hd__o21a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_382_297# w=1]]', 'g: [connection X0/g =>[signal: A1 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__078__0 _078__a_382_297# cnt2[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_297_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__078__1 VGND cnt2[1] _078__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_297_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__078__2 _078__a_79_21# _045_ _078__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_79_21# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__078__3 _002_ _078__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_297_47# w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__078__4 _078__a_297_47# _042_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_79_21# w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_382_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__078__5 _078__a_79_21# _042_ _078__a_382_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_79_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__078__6 VPWR _045_ _078__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_79_21# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__078__7 _002_ _078__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _080_ with the contents of sky130_fd_sc_hd__o21a_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__080__0 _080__a_384_47# _026_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_79_21# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__080__1 _047_ _080__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_470_297# w=1]]', 'g: [connection X2/g =>[signal: A1 w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__080__2 _080__a_470_297# _025_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_79_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__080__3 VPWR _022_ _080__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_384_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__080__4 VGND _025_ _080__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_79_21# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__080__5 VGND _080__a_79_21# _047_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_79_21# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__080__6 VPWR _080__a_79_21# _047_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_79_21# w=1]]', 'g: [connection X7/g =>[signal: A2 w=1]]', 's: [connection X7/s =>[signal: a_470_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__080__7 _080__a_79_21# _026_ _080__a_470_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_79_21# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__080__8 _047_ _080__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_79_21# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: a_384_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__080__9 _080__a_79_21# _022_ _080__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _081_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__081__0 VPWR _031_ _081__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__081__1 _081__a_76_199# _046_ _081__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__081__2 _081__a_535_374# _081__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__081__3 VPWR _031_ _081__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__081__4 _081__a_76_199# _047_ _081__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__081__5 _081__a_218_47# _047_ _081__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__081__6 _081__a_218_374# _046_ _081__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__081__7 _048_ _081__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__081__8 _048_ _081__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__081__9 VGND _031_ _081__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__081__10 VGND _031_ _081__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__081__11 _081__a_439_47# _081__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _082_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__082__0 VGND _048_ _082__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__082__1 _003_ _082__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__082__2 _003_ _082__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__082__3 VPWR _048_ _082__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _083_ with the contents of sky130_fd_sc_hd__or2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_150_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__083__0 _083__a_150_297# _031_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_68_297# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__083__1 VGND _083__a_68_297# _049_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_68_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__083__2 VGND _030_ _083__a_68_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_68_297# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__083__3 _083__a_68_297# _031_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_68_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_150_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__083__4 _083__a_68_297# _030_ _083__a_150_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_68_297# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__083__5 VPWR _083__a_68_297# _049_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _084_ with the contents of sky130_fd_sc_hd__nand2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__084__0 _050_ _031_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__084__1 VPWR _030_ _050_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_113_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__084__2 VGND _030_ _084__a_113_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_113_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__084__3 _084__a_113_47# _031_ _050_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _085_ with the contents of sky130_fd_sc_hd__a32o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_93_21# w=1]]', 'g: [connection X0/g =>[signal: B2 w=1]]', 's: [connection X0/s =>[signal: a_250_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__085__0 _085__a_93_21# _030_ _085__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_93_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__085__1 _004_ _085__a_93_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_250_297# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_93_21# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__085__2 _085__a_250_297# _047_ _085__a_93_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_256_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_346_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__085__3 _085__a_256_47# _049_ _085__a_346_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_93_21# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__085__4 _004_ _085__a_93_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A3 w=1]]', 's: [connection X5/s =>[signal: a_256_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__085__5 VGND _050_ _085__a_256_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_93_21# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_584_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__085__6 _085__a_93_21# _047_ _085__a_584_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_250_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__085__7 VPWR _033_ _085__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_346_47# w=1]]', 'g: [connection X8/g =>[signal: A1 w=1]]', 's: [connection X8/s =>[signal: a_93_21# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__085__8 _085__a_346_47# _033_ _085__a_93_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_250_297# w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__085__9 _085__a_250_297# _049_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VPWR w=1]]', 'g: [connection X10/g =>[signal: A3 w=1]]', 's: [connection X10/s =>[signal: a_250_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__085__10 VPWR _050_ _085__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_584_47# w=1]]', 'g: [connection X11/g =>[signal: B2 w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__085__11 _085__a_584_47# _030_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _086_ with the contents of sky130_fd_sc_hd__nand3_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: Y w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__086__0 VPWR _031_ _051_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_109_47# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_193_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__086__1 _086__a_109_47# _030_ _086__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: C w=1]]', 's: [connection X2/s =>[signal: a_109_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__086__2 VGND cnt1[2] _086__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_193_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__086__3 _086__a_193_47# _031_ _051_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: Y w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__086__4 VPWR cnt1[2] _051_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__086__5 _051_ _030_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _087_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__087__0 _087__a_384_47# _030_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__087__1 _052_ _087__a_81_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__087__2 _087__a_81_21# cnt1[2] _087__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__087__3 VGND cnt1[2] _087__a_81_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__087__4 _087__a_299_297# _031_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__087__5 VPWR _030_ _087__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__087__6 _052_ _087__a_81_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__087__7 _087__a_81_21# _031_ _087__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _088_ with the contents of sky130_fd_sc_hd__a32o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_93_21# w=1]]', 'g: [connection X0/g =>[signal: B2 w=1]]', 's: [connection X0/s =>[signal: a_250_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__088__0 _088__a_93_21# _047_ _088__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_93_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__088__1 _005_ _088__a_93_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_250_297# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_93_21# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__088__2 _088__a_250_297# cnt1[2] _088__a_93_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_256_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_346_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__088__3 _088__a_256_47# _051_ _088__a_346_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_93_21# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__088__4 _005_ _088__a_93_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A3 w=1]]', 's: [connection X5/s =>[signal: a_256_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__088__5 VGND _052_ _088__a_256_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_93_21# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_584_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__088__6 _088__a_93_21# cnt1[2] _088__a_584_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_250_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__088__7 VPWR _046_ _088__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_346_47# w=1]]', 'g: [connection X8/g =>[signal: A1 w=1]]', 's: [connection X8/s =>[signal: a_93_21# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__088__8 _088__a_346_47# _046_ _088__a_93_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_250_297# w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__088__9 _088__a_250_297# _051_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VPWR w=1]]', 'g: [connection X10/g =>[signal: A3 w=1]]', 's: [connection X10/s =>[signal: a_250_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__088__10 VPWR _052_ _088__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_584_47# w=1]]', 'g: [connection X11/g =>[signal: B2 w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__088__11 _088__a_584_47# _047_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _089_ with the contents of sky130_fd_sc_hd__and4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_197_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: a_303_47# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__089__0 _089__a_197_47# cnt1[3] _089__a_303_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_303_47# w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__089__1 _089__a_303_47# cnt1[2] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__089__2 VGND _089__a_27_47# _053_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_27_47# w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__089__3 _089__a_27_47# cnt1[2] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_27_47# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__089__4 VPWR cnt1[3] _089__a_27_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_109_47# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_197_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__089__5 _089__a_109_47# _030_ _089__a_197_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__089__6 VPWR _089__a_27_47# _053_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_27_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__089__7 VPWR _031_ _089__a_27_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_47# w=1]]', 'g: [connection X8/g =>[signal: B w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__089__8 _089__a_27_47# _030_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_27_47# w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_109_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__089__9 _089__a_27_47# _031_ _089__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _091_ with the contents of sky130_fd_sc_hd__a31o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_80_21# w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__091__0 _091__a_80_21# cnt1[3] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_80_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__091__1 _055_ _091__a_80_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_209_47# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: a_303_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__091__2 _091__a_209_47# _030_ _091__a_303_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_80_21# w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__091__3 _055_ _091__a_80_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_303_47# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_80_21# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__091__4 _091__a_303_47# _031_ _091__a_80_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_209_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__091__5 VPWR _031_ _091__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_209_297# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_80_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__091__6 _091__a_209_297# cnt1[3] _091__a_80_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_209_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__091__7 VGND cnt1[2] _091__a_209_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_209_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__091__8 _091__a_209_297# _030_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_209_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__091__9 VPWR cnt1[2] _091__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _092_ with the contents of sky130_fd_sc_hd__a32o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_93_21# w=1]]', 'g: [connection X0/g =>[signal: B2 w=1]]', 's: [connection X0/s =>[signal: a_250_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__092__0 _092__a_93_21# _047_ _092__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_93_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__092__1 _006_ _092__a_93_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_250_297# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_93_21# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__092__2 _092__a_250_297# cnt1[3] _092__a_93_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_256_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_346_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__092__3 _092__a_256_47# _054_ _092__a_346_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_93_21# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__092__4 _006_ _092__a_93_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A3 w=1]]', 's: [connection X5/s =>[signal: a_256_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__092__5 VGND _055_ _092__a_256_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_93_21# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_584_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__092__6 _092__a_93_21# cnt1[3] _092__a_584_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_250_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__092__7 VPWR _046_ _092__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_346_47# w=1]]', 'g: [connection X8/g =>[signal: A1 w=1]]', 's: [connection X8/s =>[signal: a_93_21# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__092__8 _092__a_346_47# _046_ _092__a_93_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_250_297# w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__092__9 _092__a_250_297# _054_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VPWR w=1]]', 'g: [connection X10/g =>[signal: A3 w=1]]', 's: [connection X10/s =>[signal: a_250_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__092__10 VPWR _055_ _092__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_584_47# w=1]]', 'g: [connection X11/g =>[signal: B2 w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__092__11 _092__a_584_47# _047_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _093_ with the contents of sky130_fd_sc_hd__nand2_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_27_47# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__093__0 _056_ cnt1[4] _093__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__093__1 _093__a_27_47# cnt1[4] _056_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__093__2 VGND _053_ _093__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__093__3 VPWR cnt1[4] _056_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__093__4 _093__a_27_47# _053_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: Y w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__093__5 VPWR _053_ _056_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: Y w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__093__6 _056_ _053_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: Y w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__093__7 _056_ cnt1[4] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _094_ with the contents of sky130_fd_sc_hd__or2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_150_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__094__0 _094__a_150_297# cnt1[4] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_68_297# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__094__1 VGND _094__a_68_297# _057_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_68_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__094__2 VGND _053_ _094__a_68_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_68_297# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__094__3 _094__a_68_297# cnt1[4] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_68_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_150_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__094__4 _094__a_68_297# _053_ _094__a_150_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_68_297# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__094__5 VPWR _094__a_68_297# _057_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _095_ with the contents of sky130_fd_sc_hd__a32o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_93_21# w=1]]', 'g: [connection X0/g =>[signal: B2 w=1]]', 's: [connection X0/s =>[signal: a_250_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__095__0 _095__a_93_21# _047_ _095__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_93_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__095__1 _007_ _095__a_93_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_250_297# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_93_21# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__095__2 _095__a_250_297# cnt1[4] _095__a_93_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_256_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_346_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__095__3 _095__a_256_47# _056_ _095__a_346_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_93_21# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__095__4 _007_ _095__a_93_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A3 w=1]]', 's: [connection X5/s =>[signal: a_256_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__095__5 VGND _057_ _095__a_256_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_93_21# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_584_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__095__6 _095__a_93_21# cnt1[4] _095__a_584_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_250_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__095__7 VPWR _046_ _095__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_346_47# w=1]]', 'g: [connection X8/g =>[signal: A1 w=1]]', 's: [connection X8/s =>[signal: a_93_21# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__095__8 _095__a_346_47# _046_ _095__a_93_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_250_297# w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__095__9 _095__a_250_297# _056_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VPWR w=1]]', 'g: [connection X10/g =>[signal: A3 w=1]]', 's: [connection X10/s =>[signal: a_250_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__095__10 VPWR _057_ _095__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_584_47# w=1]]', 'g: [connection X11/g =>[signal: B2 w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__095__11 _095__a_584_47# _047_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _096_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__096__0 _096__a_384_47# _056_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__096__1 _058_ _096__a_81_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__096__2 _096__a_81_21# _047_ _096__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__096__3 VGND _047_ _096__a_81_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__096__4 _096__a_299_297# _033_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__096__5 VPWR _056_ _096__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__096__6 _058_ _096__a_81_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__096__7 _096__a_81_21# _033_ _096__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _097_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__097__0 _097__a_109_297# cnt1[5] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__097__1 _059_ cnt1[5] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__097__2 VGND _056_ _059_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__097__3 _059_ _056_ _097__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _098_ with the contents of sky130_fd_sc_hd__a22o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__098__0 _098__a_109_297# _058_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_109_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__098__1 VPWR cnt1[5] _098__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_373_47# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__098__2 _098__a_373_47# _058_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_109_47# w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_27_297# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__098__3 _098__a_109_47# _059_ _098__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: a_27_297# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__098__4 VGND _098__a_27_297# _008_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_373_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__098__5 _098__a_27_297# cnt1[5] _098__a_373_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_27_297# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__098__6 VPWR _098__a_27_297# _008_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B2 w=1]]', 's: [connection X7/s =>[signal: a_109_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__098__7 VGND _046_ _098__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: B2 w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__098__8 _098__a_27_297# _046_ _098__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_109_297# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: a_27_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__098__9 _098__a_109_297# _059_ _098__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _099_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__099__0 _099__a_109_297# _022_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__099__1 _060_ _022_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__099__2 VGND cnt3[0] _060_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__099__3 _060_ cnt3[0] _099__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _100_ with the contents of sky130_fd_sc_hd__a31o_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_277_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: a_361_47# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__100__0 _100__a_277_47# _029_ _100__a_361_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_361_47# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_79_21# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__100__1 _100__a_361_47# _026_ _100__a_79_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__100__2 _100__a_79_21# _022_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: A3 w=1]]', 's: [connection X3/s =>[signal: a_277_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__100__3 VGND _032_ _100__a_277_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_277_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__100__4 VPWR _026_ _100__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_277_297# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: a_79_21# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__100__5 _100__a_277_297# _022_ _100__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_79_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__100__6 _061_ _100__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_277_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__100__7 VPWR _032_ _100__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_79_21# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__100__8 VGND _100__a_79_21# _061_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_79_21# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__100__9 VPWR _100__a_79_21# _061_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_79_21# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__100__10 _061_ _100__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_277_297# w=1]]', 'g: [connection X11/g =>[signal: A2 w=1]]', 's: [connection X11/s =>[signal: VPWR w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__100__11 _100__a_277_297# _029_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _101_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__101__0 VGND _101__a_59_75# _062_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__101__1 VPWR _035_ _101__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__101__2 _101__a_59_75# _035_ _101__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__101__3 _101__a_59_75# _061_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__101__4 _101__a_145_75# _061_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__101__5 VPWR _101__a_59_75# _062_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _102_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__102__0 VPWR _062_ _102__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__102__1 _102__a_76_199# cnt3[0] _102__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__102__2 _102__a_535_374# _102__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__102__3 VPWR _062_ _102__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__102__4 _102__a_76_199# _060_ _102__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__102__5 _102__a_218_47# _060_ _102__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__102__6 _102__a_218_374# cnt3[0] _102__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__102__7 _063_ _102__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__102__8 _063_ _102__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__102__9 VGND _062_ _102__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__102__10 VGND _062_ _102__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__102__11 _102__a_439_47# _102__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _103_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__103__0 VGND _063_ _103__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__103__1 _009_ _103__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__103__2 _009_ _103__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__103__3 VPWR _063_ _103__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _104_ with the contents of sky130_fd_sc_hd__nand2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__104__0 _064_ cnt3[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__104__1 VPWR cnt3[1] _064_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_113_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__104__2 VGND cnt3[1] _104__a_113_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_113_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__104__3 _104__a_113_47# cnt3[0] _064_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _105_ with the contents of sky130_fd_sc_hd__o211a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: C1 w=1]]', 's: [connection X0/s =>[signal: a_79_21# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__105__0 VPWR _064_ _105__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_215_47# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__105__1 _105__a_215_47# cnt3[0] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_215_47# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_510_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__105__2 _105__a_215_47# _039_ _105__a_510_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_297_297# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_79_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__105__3 _105__a_297_297# cnt3[1] _105__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_297_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__105__4 VPWR cnt3[0] _105__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_215_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__105__5 VGND cnt3[1] _105__a_215_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_79_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__105__6 _065_ _105__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_79_21# w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__105__7 _065_ _105__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_510_47# w=1]]', 'g: [connection X8/g =>[signal: C1 w=1]]', 's: [connection X8/s =>[signal: a_79_21# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__105__8 _105__a_510_47# _064_ _105__a_79_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_79_21# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__105__9 _105__a_79_21# _039_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _106_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__106__0 VPWR _062_ _106__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__106__1 _106__a_76_199# cnt3[1] _106__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__106__2 _106__a_535_374# _106__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__106__3 VPWR _062_ _106__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__106__4 _106__a_76_199# _065_ _106__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__106__5 _106__a_218_47# _065_ _106__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__106__6 _106__a_218_374# cnt3[1] _106__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__106__7 _066_ _106__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__106__8 _066_ _106__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__106__9 VGND _062_ _106__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__106__10 VGND _062_ _106__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__106__11 _106__a_439_47# _106__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _107_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__107__0 VGND _066_ _107__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__107__1 _010_ _107__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__107__2 _010_ _107__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__107__3 VPWR _066_ _107__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _108_ with the contents of sky130_fd_sc_hd__nand3_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: Y w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__108__0 VPWR _026_ _067_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_109_47# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_193_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__108__1 _108__a_109_47# _037_ _108__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: C w=1]]', 's: [connection X2/s =>[signal: a_109_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__108__2 VGND _038_ _108__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_193_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__108__3 _108__a_193_47# _026_ _067_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: Y w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__108__4 VPWR _038_ _067_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__108__5 _067_ _037_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _109_ with the contents of sky130_fd_sc_hd__a41o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: a_79_21# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__109__0 VGND cnt3[2] _109__a_79_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A4 w=1]]', 's: [connection X1/s =>[signal: a_297_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__109__1 VPWR _061_ _109__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_297_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__109__2 _109__a_79_21# cnt3[2] _109__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_297_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__109__3 VPWR _035_ _109__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_297_297# w=1]]', 'g: [connection X4/g =>[signal: A3 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__109__4 _109__a_297_297# cnt3[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_297_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__109__5 _109__a_297_297# cnt3[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_465_47# w=1]]', 'g: [connection X6/g =>[signal: A3 w=1]]', 's: [connection X6/s =>[signal: a_561_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__109__6 _109__a_465_47# cnt3[1] _109__a_561_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_561_47# w=1]]', 'g: [connection X7/g =>[signal: A4 w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__109__7 _109__a_561_47# _061_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_381_47# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_465_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__109__8 _109__a_381_47# _035_ _109__a_465_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: X w=1]]', 'g: [connection X9/g =>[signal: a_79_21# w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__109__9 _068_ _109__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_79_21# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__109__10 _068_ _109__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_79_21# w=1]]', 'g: [connection X11/g =>[signal: A1 w=1]]', 's: [connection X11/s =>[signal: a_381_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__109__11 _109__a_79_21# cnt3[0] _109__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _110_ with the contents of sky130_fd_sc_hd__a21boi_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__110__0 _110__a_384_47# _067_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_27_413# w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__110__1 VGND _110__a_27_413# _011_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_300_297# w=1]]', 'g: [connection X2/g =>[signal: A1 w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__110__2 _110__a_300_297# _062_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: a_27_413# w=1]]', 's: [connection X3/s =>[signal: a_300_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__110__3 _011_ _110__a_27_413# _110__a_300_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_413# w=1]]', 'g: [connection X4/g =>[signal: B1_N w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__110__4 _110__a_27_413# _068_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_384_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__110__5 _011_ _062_ _110__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_413# w=1]]', 'g: [connection X6/g =>[signal: B1_N w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__110__6 _110__a_27_413# _068_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A2 w=1]]', 's: [connection X7/s =>[signal: a_300_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__110__7 VPWR _067_ _110__a_300_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _111_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__111__0 _111__a_109_297# _022_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__111__1 _069_ _022_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__111__2 VGND cnt4[0] _069_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__111__3 _069_ cnt4[0] _111__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _112_ with the contents of sky130_fd_sc_hd__xnor2_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: a_27_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__112__0 VPWR _026_ _112__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_560_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__112__1 VGND _026_ _112__a_560_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__112__2 VPWR _025_ _112__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_474_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__112__3 _070_ _026_ _112__a_474_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_297# w=1]]', 'g: [connection X4/g =>[signal: A w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__112__4 _112__a_27_297# _025_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: a_474_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__112__5 VPWR _025_ _112__a_474_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__112__6 _112__a_27_297# _026_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_27_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__112__7 VGND _025_ _112__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_474_297# w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__112__8 _112__a_474_297# _025_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_27_47# w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__112__9 _112__a_27_47# _025_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: Y w=1]]', 'g: [connection X10/g =>[signal: a_27_297# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__112__10 _070_ _112__a_27_297# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_474_297# w=1]]', 'g: [connection X11/g =>[signal: B w=1]]', 's: [connection X11/s =>[signal: Y w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__112__11 _112__a_474_297# _026_ _070_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_560_47# w=1]]', 'g: [connection X12/g =>[signal: B w=1]]', 's: [connection X12/s =>[signal: VGND w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__112__12 _112__a_560_47# _026_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_27_297# w=1]]', 's: [connection X13/s =>[signal: Y w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X__112__13 VPWR _112__a_27_297# _070_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_27_47# w=1]]', 'g: [connection X14/g =>[signal: B w=1]]', 's: [connection X14/s =>[signal: a_27_297# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__112__14 _112__a_27_47# _026_ _112__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_560_47# w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__112__15 _112__a_560_47# _025_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: Y w=1]]', 'g: [connection X16/g =>[signal: a_27_297# w=1]]', 's: [connection X16/s =>[signal: a_560_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__112__16 _070_ _112__a_27_297# _112__a_560_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_297# w=1]]', 'g: [connection X17/g =>[signal: B w=1]]', 's: [connection X17/s =>[signal: a_27_47# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__112__17 _112__a_27_297# _026_ _112__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: A w=1]]', 's: [connection X18/s =>[signal: a_560_47# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__112__18 VGND _025_ _112__a_560_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_560_47# w=1]]', 'g: [connection X19/g =>[signal: a_27_297# w=1]]', 's: [connection X19/s =>[signal: Y w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__112__19 _112__a_560_47# _112__a_27_297# _070_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _113_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__113__0 VGND _113__a_59_75# _071_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__113__1 VPWR _061_ _113__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__113__2 _113__a_59_75# _061_ _113__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__113__3 _113__a_59_75# _070_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__113__4 _113__a_145_75# _070_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__113__5 VPWR _113__a_59_75# _071_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _114_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__114__0 VPWR _071_ _114__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__114__1 _114__a_76_199# cnt4[0] _114__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__114__2 _114__a_535_374# _114__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__114__3 VPWR _071_ _114__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__114__4 _114__a_76_199# _069_ _114__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__114__5 _114__a_218_47# _069_ _114__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__114__6 _114__a_218_374# cnt4[0] _114__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__114__7 _072_ _114__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__114__8 _072_ _114__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__114__9 VGND _071_ _114__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__114__10 VGND _071_ _114__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__114__11 _114__a_439_47# _114__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _115_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__115__0 VGND _072_ _115__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__115__1 _012_ _115__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__115__2 _012_ _115__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__115__3 VPWR _072_ _115__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _116_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__116__0 _116__a_384_47# cnt4[1] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__116__1 _016_ _116__a_81_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__116__2 _116__a_81_21# _027_ _116__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__116__3 VGND _027_ _116__a_81_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__116__4 _116__a_299_297# cnt4[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__116__5 VPWR cnt4[1] _116__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__116__6 _016_ _116__a_81_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__116__7 _116__a_81_21# cnt4[0] _116__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _117_ with the contents of sky130_fd_sc_hd__nand3_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_277_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__117__0 _117__a_277_47# _016_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: C w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__117__1 VPWR _016_ _017_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_277_47# w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__117__2 _117__a_277_47# _070_ _117__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: C w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__117__3 _017_ _016_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_277_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__117__4 _117__a_27_47# _070_ _117__a_277_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: a_277_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__117__5 VGND _016_ _117__a_277_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: Y w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: a_27_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__117__6 _017_ _061_ _117__a_27_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: Y w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__117__7 VPWR _070_ _017_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_47# w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: Y w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__117__8 _117__a_27_47# _061_ _017_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: Y w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__117__9 VPWR _061_ _017_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: Y w=1]]', 'g: [connection X10/g =>[signal: A w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__117__10 _017_ _061_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: Y w=1]]', 'g: [connection X11/g =>[signal: B w=1]]', 's: [connection X11/s =>[signal: VPWR w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__117__11 _017_ _070_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _118_ with the contents of sky130_fd_sc_hd__a31o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_80_21# w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__118__0 _118__a_80_21# cnt4[1] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_80_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__118__1 _018_ _118__a_80_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_209_47# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: a_303_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__118__2 _118__a_209_47# _061_ _118__a_303_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_80_21# w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__118__3 _018_ _118__a_80_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_303_47# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_80_21# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__118__4 _118__a_303_47# cnt4[0] _118__a_80_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_209_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__118__5 VPWR cnt4[0] _118__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_209_297# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_80_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__118__6 _118__a_209_297# cnt4[1] _118__a_80_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_209_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__118__7 VGND _070_ _118__a_209_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_209_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__118__8 _118__a_209_297# _061_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_209_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__118__9 VPWR _070_ _118__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _119_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__119__0 VGND _119__a_59_75# _019_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__119__1 VPWR _017_ _119__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__119__2 _119__a_59_75# _017_ _119__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__119__3 _119__a_59_75# _018_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__119__4 _119__a_145_75# _018_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__119__5 VPWR _119__a_59_75# _019_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _120_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__120__0 VGND _019_ _120__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__120__1 _013_ _120__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__120__2 _013_ _120__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__120__3 VPWR _019_ _120__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _121_ with the contents of sky130_fd_sc_hd__a32o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_93_21# w=1]]', 'g: [connection X0/g =>[signal: B2 w=1]]', 's: [connection X0/s =>[signal: a_250_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__121__0 _121__a_93_21# cnt4[2] _121__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_93_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__121__1 _014_ _121__a_93_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_250_297# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_93_21# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__121__2 _121__a_250_297# _017_ _121__a_93_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_256_47# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_346_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__121__3 _121__a_256_47# _028_ _121__a_346_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_93_21# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__121__4 _014_ _121__a_93_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A3 w=1]]', 's: [connection X5/s =>[signal: a_256_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__121__5 VGND _071_ _121__a_256_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_93_21# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_584_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__121__6 _121__a_93_21# _017_ _121__a_584_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_250_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__121__7 VPWR _024_ _121__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_346_47# w=1]]', 'g: [connection X8/g =>[signal: A1 w=1]]', 's: [connection X8/s =>[signal: a_93_21# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__121__8 _121__a_346_47# _024_ _121__a_93_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_250_297# w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__121__9 _121__a_250_297# _028_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VPWR w=1]]', 'g: [connection X10/g =>[signal: A3 w=1]]', 's: [connection X10/s =>[signal: a_250_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__121__10 VPWR _071_ _121__a_250_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_584_47# w=1]]', 'g: [connection X11/g =>[signal: B2 w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__121__11 _121__a_584_47# cnt4[2] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _122_ with the contents of sky130_fd_sc_hd__and4b_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_193_413# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__122__0 VPWR _122__a_193_413# _020_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_193_413# w=1]]', 'g: [connection X1/g =>[signal: a_27_47# w=1]]', 's: [connection X1/s =>[signal: a_297_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__122__1 _122__a_193_413# _122__a_27_47# _122__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_193_413# w=1]]', 'g: [connection X2/g =>[signal: D w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__122__2 _122__a_193_413# cnt4[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: C w=1]]', 's: [connection X3/s =>[signal: a_193_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__122__3 VPWR cnt4[1] _122__a_193_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_369_47# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_469_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__122__4 _122__a_369_47# cnt4[1] _122__a_469_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A_N w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__122__5 _122__a_27_47# cnt4[3] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_193_413# w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__122__6 _122__a_193_413# cnt4[2] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_193_413# w=1]]', 's: [connection X7/s =>[signal: X w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__122__7 VGND _122__a_193_413# _020_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VPWR w=1]]', 'g: [connection X8/g =>[signal: a_27_47# w=1]]', 's: [connection X8/s =>[signal: a_193_413# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__122__8 VPWR _122__a_27_47# _122__a_193_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_27_47# w=1]]', 'g: [connection X9/g =>[signal: A_N w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__122__9 _122__a_27_47# cnt4[3] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_297_47# w=1]]', 'g: [connection X10/g =>[signal: B w=1]]', 's: [connection X10/s =>[signal: a_369_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__122__10 _122__a_297_47# cnt4[2] _122__a_369_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_469_47# w=1]]', 'g: [connection X11/g =>[signal: D w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__122__11 _122__a_469_47# cnt4[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _123_ with the contents of sky130_fd_sc_hd__and2b_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_207_413# w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__123__0 _123__a_207_413# _020_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_207_413# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__123__1 VPWR _123__a_207_413# _021_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_207_413# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__123__2 VGND _123__a_207_413# _021_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_207_413# w=1]]', 'g: [connection X3/g =>[signal: a_27_413# w=1]]', 's: [connection X3/s =>[signal: a_297_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__123__3 _123__a_207_413# _123__a_27_413# _123__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_413# w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__123__4 _123__a_27_413# _027_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_27_413# w=1]]', 's: [connection X5/s =>[signal: a_207_413# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__123__5 VPWR _123__a_27_413# _123__a_207_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: A_N w=1]]', 's: [connection X6/s =>[signal: a_27_413# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__123__6 VGND _027_ _123__a_27_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_297_47# w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__123__7 _123__a_297_47# _020_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _124_ with the contents of sky130_fd_sc_hd__a22o_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__124__0 _124__a_109_297# _017_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_109_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__124__1 VPWR cnt4[3] _124__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_373_47# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__124__2 _124__a_373_47# _017_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_109_47# w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_27_297# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__124__3 _124__a_109_47# _021_ _124__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: a_27_297# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__124__4 VGND _124__a_27_297# _015_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_373_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__124__5 _124__a_27_297# cnt4[3] _124__a_373_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_27_297# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__124__6 VPWR _124__a_27_297# _015_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B2 w=1]]', 's: [connection X7/s =>[signal: a_109_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__124__7 VGND _071_ _124__a_109_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: B2 w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__124__8 _124__a_27_297# _071_ _124__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_109_297# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: a_27_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__124__9 _124__a_109_297# _021_ _124__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _125_ with the contents of sky130_fd_sc_hd__clkbuf_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__125__0 VPWR _125__a_27_47# _022_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_27_47# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__125__1 _022_ _125__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_27_47# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__125__2 _125__a_27_47# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_27_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__125__3 _125__a_27_47# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__125__4 _022_ _125__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__125__5 VGND _125__a_27_47# _022_ VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__125__6 _022_ _125__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: X w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__125__7 VGND _125__a_27_47# _022_ VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_27_47# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__125__8 _022_ _125__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_47# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__125__9 VPWR _125__a_27_47# _022_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _126_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__126__0 _126__a_109_297# _022_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__126__1 _023_ _022_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__126__2 VGND net4 _023_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__126__3 _023_ net4 _126__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _127_ with the contents of sky130_fd_sc_hd__and3b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_209_311# w=1]]', 'g: [connection X0/g =>[signal: a_109_93# w=1]]', 's: [connection X0/s =>[signal: a_296_53# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__127__0 _127__a_209_311# _127__a_109_93# _127__a_296_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_209_311# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__127__1 VGND _127__a_209_311# _024_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: A_N w=1]]', 's: [connection X2/s =>[signal: a_109_93# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__127__2 VGND cnt4[2] _127__a_109_93# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_209_311# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__127__3 VPWR _127__a_209_311# _024_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: a_109_93# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__127__4 VPWR cnt4[2] _127__a_109_93# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_368_53# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__127__5 _127__a_368_53# cnt4[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_209_311# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__127__6 VPWR cnt4[1] _127__a_209_311# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_209_311# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__127__7 _127__a_209_311# cnt4[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_296_53# w=1]]', 'g: [connection X8/g =>[signal: B w=1]]', 's: [connection X8/s =>[signal: a_368_53# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__127__8 _127__a_296_53# cnt4[1] _127__a_368_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_209_311# w=1]]', 'g: [connection X9/g =>[signal: a_109_93# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__127__9 _127__a_209_311# _127__a_109_93# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _128_ with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__128__0 _025_ _128__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__128__1 _128__a_27_47# net2 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__128__2 VGND _128__a_27_47# _025_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__128__3 _025_ _128__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__128__4 VPWR _128__a_27_47# _025_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__128__5 _128__a_27_47# net2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _129_ with the contents of sky130_fd_sc_hd__clkbuf_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__129__0 VPWR _129__a_27_47# _026_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_27_47# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__129__1 _026_ _129__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_27_47# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__129__2 _129__a_27_47# net3 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_27_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__129__3 _129__a_27_47# net3 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__129__4 _026_ _129__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__129__5 VGND _129__a_27_47# _026_ VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__129__6 _026_ _129__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: X w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__129__7 VGND _129__a_27_47# _026_ VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_27_47# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__129__8 _026_ _129__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_47# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__129__9 VPWR _129__a_27_47# _026_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _130_ with the contents of sky130_fd_sc_hd__nand3b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_53_93# w=1]]', 'g: [connection X0/g =>[signal: A_N w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__130__0 _130__a_53_93# net1 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_232_47# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_316_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__130__1 _130__a_232_47# _025_ _130__a_316_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_53_93# w=1]]', 'g: [connection X2/g =>[signal: A_N w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__130__2 _130__a_53_93# net1 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: C w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__130__3 VPWR _026_ _027_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_316_47# w=1]]', 'g: [connection X4/g =>[signal: a_53_93# w=1]]', 's: [connection X4/s =>[signal: Y w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__130__4 _130__a_316_47# _130__a_53_93# _027_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_53_93# w=1]]', 's: [connection X5/s =>[signal: Y w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__130__5 VPWR _130__a_53_93# _027_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: Y w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__130__6 _027_ _025_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: a_232_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__130__7 VGND _026_ _130__a_232_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _131_ with the contents of sky130_fd_sc_hd__a21oi_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: a_114_47# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__131__0 VGND _024_ _131__a_114_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__131__1 VPWR cnt4[3] _131__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_27_297# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__131__2 _131__a_27_297# _024_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_27_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__131__3 VPWR _024_ _131__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: Y w=1]]', 'g: [connection X4/g =>[signal: B1 w=1]]', 's: [connection X4/s =>[signal: a_27_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__131__4 _028_ _027_ _131__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__131__5 _028_ _027_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: A1 w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__131__6 _131__a_27_297# cnt4[3] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_297# w=1]]', 'g: [connection X7/g =>[signal: B1 w=1]]', 's: [connection X7/s =>[signal: Y w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__131__7 _131__a_27_297# _027_ _028_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: B1 w=1]]', 's: [connection X8/s =>[signal: Y w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__131__8 VGND _027_ _028_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_285_47# w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__131__9 _131__a_285_47# _024_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_114_47# w=1]]', 'g: [connection X10/g =>[signal: A1 w=1]]', 's: [connection X10/s =>[signal: Y w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__131__10 _131__a_114_47# cnt4[3] _028_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: Y w=1]]', 'g: [connection X11/g =>[signal: A1 w=1]]', 's: [connection X11/s =>[signal: a_285_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__131__11 _028_ cnt4[3] _131__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _132_ with the contents of sky130_fd_sc_hd__nor4b_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_277_297# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: a_474_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__132__0 _132__a_277_297# cnt1[4] _132__a_474_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: a_694_21# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__132__1 _029_ _132__a_694_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__132__2 _029_ cnt1[2] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_694_21# w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__132__3 VGND _132__a_694_21# _029_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: Y w=1]]', 'g: [connection X4/g =>[signal: a_694_21# w=1]]', 's: [connection X4/s =>[signal: a_474_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__132__4 _029_ _132__a_694_21# _132__a_474_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: Y w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__132__5 VGND cnt1[4] _029_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_474_297# w=1]]', 'g: [connection X6/g =>[signal: a_694_21# w=1]]', 's: [connection X6/s =>[signal: Y w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__132__6 _132__a_474_297# _132__a_694_21# _029_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: Y w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__132__7 VGND cnt1[2] _029_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_694_21# w=1]]', 'g: [connection X8/g =>[signal: D_N w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__132__8 _132__a_694_21# cnt1[5] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: Y w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__132__9 _029_ cnt1[3] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_27_297# w=1]]', 'g: [connection X10/g =>[signal: B w=1]]', 's: [connection X10/s =>[signal: a_277_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__132__10 _132__a_27_297# cnt1[2] _132__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VGND w=1]]', 'g: [connection X11/g =>[signal: A w=1]]', 's: [connection X11/s =>[signal: Y w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__132__11 VGND cnt1[3] _029_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_27_297# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__132__12 _132__a_27_297# cnt1[3] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_474_297# w=1]]', 'g: [connection X13/g =>[signal: C w=1]]', 's: [connection X13/s =>[signal: a_277_297# w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X__132__13 _132__a_474_297# cnt1[4] _132__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: VPWR w=1]]', 'g: [connection X14/g =>[signal: A w=1]]', 's: [connection X14/s =>[signal: a_27_297# w=1]]', 'b: [connection X14/b =>[signal: VPB w=1]]']]
X__132__14 VPWR cnt1[3] _132__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: Y w=1]]', 'g: [connection X15/g =>[signal: C w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__132__15 _029_ cnt1[4] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X16 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_277_297# w=1]]', 'g: [connection X16/g =>[signal: B w=1]]', 's: [connection X16/s =>[signal: a_27_297# w=1]]', 'b: [connection X16/b =>[signal: VPB w=1]]']]
X__132__16 _132__a_277_297# cnt1[2] _132__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_694_21# w=1]]', 'g: [connection X17/g =>[signal: D_N w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__132__17 _132__a_694_21# cnt1[5] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _133_ with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__133__0 _030_ _133__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__133__1 _133__a_27_47# cnt1[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__133__2 VGND _133__a_27_47# _030_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__133__3 _030_ _133__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__133__4 VPWR _133__a_27_47# _030_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__133__5 _133__a_27_47# cnt1[1] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _134_ with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__134__0 _031_ _134__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__134__1 _134__a_27_47# cnt1[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__134__2 VGND _134__a_27_47# _031_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__134__3 _031_ _134__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__134__4 VPWR _134__a_27_47# _031_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__134__5 _134__a_27_47# cnt1[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _135_ with the contents of sky130_fd_sc_hd__and2b_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_207_413# w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__135__0 _135__a_207_413# _031_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_207_413# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__135__1 VPWR _135__a_207_413# _032_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_207_413# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__135__2 VGND _135__a_207_413# _032_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_207_413# w=1]]', 'g: [connection X3/g =>[signal: a_27_413# w=1]]', 's: [connection X3/s =>[signal: a_297_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__135__3 _135__a_207_413# _135__a_27_413# _135__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_413# w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__135__4 _135__a_27_413# _030_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_27_413# w=1]]', 's: [connection X5/s =>[signal: a_207_413# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__135__5 VPWR _135__a_27_413# _135__a_207_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: A_N w=1]]', 's: [connection X6/s =>[signal: a_27_413# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__135__6 VGND _030_ _135__a_27_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_297_47# w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__135__7 _135__a_297_47# _031_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _136_ with the contents of sky130_fd_sc_hd__a21oi_4
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: a_462_47# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__136__0 VGND _032_ _136__a_462_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: B1 w=1]]', 's: [connection X1/s =>[signal: a_28_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__136__1 _033_ _022_ _136__a_28_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_28_297# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__136__2 _136__a_28_297# _032_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__136__3 _033_ _022_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_28_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__136__4 _136__a_28_297# _029_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_28_297# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: Y w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__136__5 _136__a_28_297# _022_ _033_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: A1 w=1]]', 's: [connection X6/s =>[signal: a_28_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__136__6 VPWR _029_ _136__a_28_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_28_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__136__7 VPWR _029_ _136__a_28_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: B1 w=1]]', 's: [connection X8/s =>[signal: Y w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__136__8 VGND _022_ _033_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: Y w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: a_28_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__136__9 _033_ _022_ _136__a_28_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_28_297# w=1]]', 'g: [connection X10/g =>[signal: B1 w=1]]', 's: [connection X10/s =>[signal: Y w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__136__10 _136__a_28_297# _022_ _033_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: A2 w=1]]', 's: [connection X11/s =>[signal: a_28_297# w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__136__11 VPWR _032_ _136__a_28_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_28_297# w=1]]', 'g: [connection X12/g =>[signal: A2 w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__136__12 _136__a_28_297# _032_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_462_47# w=1]]', 'g: [connection X13/g =>[signal: A1 w=1]]', 's: [connection X13/s =>[signal: Y w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__136__13 _136__a_462_47# _029_ _033_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X14 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_28_297# w=1]]', 'g: [connection X14/g =>[signal: A1 w=1]]', 's: [connection X14/s =>[signal: VPWR w=1]]', 'b: [connection X14/b =>[signal: VPB w=1]]']]
X__136__14 _136__a_28_297# _029_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A2 w=1]]', 's: [connection X15/s =>[signal: a_28_297# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__136__15 VPWR _032_ _136__a_28_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: A2 w=1]]', 's: [connection X16/s =>[signal: a_462_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__136__16 VGND _032_ _136__a_462_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_462_47# w=1]]', 'g: [connection X17/g =>[signal: A2 w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__136__17 _136__a_462_47# _032_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: Y w=1]]', 'g: [connection X18/g =>[signal: A1 w=1]]', 's: [connection X18/s =>[signal: a_462_47# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__136__18 _033_ _029_ _136__a_462_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_462_47# w=1]]', 'g: [connection X19/g =>[signal: A2 w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__136__19 _136__a_462_47# _032_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X20 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: Y w=1]]', 'g: [connection X20/g =>[signal: B1 w=1]]', 's: [connection X20/s =>[signal: VGND w=1]]', 'b: [connection X20/b =>[signal: VNB w=1]]']]
X__136__20 _033_ _022_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: B1 w=1]]', 's: [connection X21/s =>[signal: Y w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__136__21 VGND _022_ _033_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_462_47# w=1]]', 'g: [connection X22/g =>[signal: A1 w=1]]', 's: [connection X22/s =>[signal: Y w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__136__22 _136__a_462_47# _029_ _033_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: Y w=1]]', 'g: [connection X23/g =>[signal: A1 w=1]]', 's: [connection X23/s =>[signal: a_462_47# w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__136__23 _033_ _029_ _136__a_462_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _139_ with the contents of sky130_fd_sc_hd__a2111oi_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: C1 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__139__0 _036_ _022_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: B1 w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__139__1 VGND _035_ _036_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_316_297# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_420_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__139__2 _139__a_316_297# _035_ _139__a_420_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: A1 w=1]]', 's: [connection X3/s =>[signal: a_568_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__139__3 _036_ _034_ _139__a_568_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: Y w=1]]', 'g: [connection X4/g =>[signal: D1 w=1]]', 's: [connection X4/s =>[signal: a_217_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__139__4 _036_ _026_ _139__a_217_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_420_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__139__5 _139__a_420_297# _034_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_568_47# w=1]]', 'g: [connection X6/g =>[signal: A2 w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__139__6 _139__a_568_47# cnt2[1] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: D1 w=1]]', 's: [connection X7/s =>[signal: Y w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__139__7 VGND _026_ _036_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_217_297# w=1]]', 'g: [connection X8/g =>[signal: C1 w=1]]', 's: [connection X8/s =>[signal: a_316_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__139__8 _139__a_217_297# _022_ _139__a_316_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: a_420_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__139__9 VPWR cnt2[1] _139__a_420_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _140_ with the contents of sky130_fd_sc_hd__nand2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__140__0 _037_ cnt3[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__140__1 VPWR cnt3[2] _037_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_113_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__140__2 VGND cnt3[2] _140__a_113_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_113_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__140__3 _140__a_113_47# cnt3[0] _037_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _141_ with the contents of sky130_fd_sc_hd__nor2_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__141__0 _038_ _025_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__141__1 VPWR _022_ _141__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__141__2 _038_ _025_ _141__a_27_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__141__3 VGND _025_ _038_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: Y w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__141__4 _141__a_27_297# _025_ _038_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_297# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__141__5 _141__a_27_297# _022_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: Y w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__141__6 VGND _022_ _038_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: Y w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__141__7 _038_ _022_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _142_ with the contents of sky130_fd_sc_hd__o211a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: C1 w=1]]', 's: [connection X0/s =>[signal: a_79_21# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__142__0 VPWR _026_ _142__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_215_47# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__142__1 _142__a_215_47# cnt3[1] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_215_47# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_510_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__142__2 _142__a_215_47# _038_ _142__a_510_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_297_297# w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_79_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__142__3 _142__a_297_297# _037_ _142__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_297_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__142__4 VPWR cnt3[1] _142__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_215_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__142__5 VGND _037_ _142__a_215_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_79_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__142__6 _039_ _142__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_79_21# w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__142__7 _039_ _142__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_510_47# w=1]]', 'g: [connection X8/g =>[signal: C1 w=1]]', 's: [connection X8/s =>[signal: a_79_21# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__142__8 _142__a_510_47# _026_ _142__a_79_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_79_21# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__142__9 _142__a_79_21# _038_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _143_ with the contents of sky130_fd_sc_hd__or4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__143__0 _143__a_27_297# _028_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__143__1 VGND _039_ _143__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__143__2 VGND _033_ _143__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_27_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__143__3 VGND _143__a_27_297# _040_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_297# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_205_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__143__4 _143__a_109_297# _036_ _143__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_205_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_277_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__143__5 _143__a_205_297# _033_ _143__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: C w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__143__6 _143__a_27_297# _036_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_297# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__143__7 _143__a_277_297# _028_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: D w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__143__8 _143__a_27_297# _039_ _143__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__143__9 VPWR _143__a_27_297# _040_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _144_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__144__0 VPWR _040_ _144__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__144__1 _144__a_76_199# _023_ _144__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__144__2 _144__a_535_374# _144__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__144__3 VPWR _040_ _144__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__144__4 _144__a_76_199# net4 _144__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__144__5 _144__a_218_47# net4 _144__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__144__6 _144__a_218_374# _023_ _144__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__144__7 _041_ _144__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__144__8 _041_ _144__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__144__9 VGND _040_ _144__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__144__10 VGND _040_ _144__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__144__11 _144__a_439_47# _144__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _145_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__145__0 VGND _041_ _145__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__145__1 _000_ _145__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__145__2 _000_ _145__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__145__3 VPWR _041_ _145__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _146_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__146__0 _146__a_891_413# _146__a_193_47# _146__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__146__1 _146__a_1059_315# _146__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__146__2 _146__a_466_413# _146__a_27_47# _146__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__146__3 _146__a_634_159# _146__a_27_47# _146__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__146__4 _146__a_381_47# _146__a_193_47# _146__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__146__5 VPWR _000_ _146__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__146__6 VPWR _146__a_466_413# _146__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__146__7 VGND _146__a_466_413# _146__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__146__8 _146__a_1017_47# _146__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__146__9 _146__a_1059_315# _146__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__146__10 _146__a_561_413# _146__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__146__11 VPWR _146__a_1059_315# net4 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__146__12 _146__a_891_413# _146__a_27_47# _146__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__146__13 _146__a_634_159# _146__a_193_47# _146__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__146__14 _146__a_592_47# _146__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__146__15 _146__a_466_413# _146__a_193_47# _146__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__146__16 VGND _146__a_27_47# _146__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__146__17 _146__a_381_47# _146__a_27_47# _146__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__146__18 _146__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__146__19 _146__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__146__20 VPWR _146__a_27_47# _146__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__146__21 VGND _000_ _146__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__146__22 _146__a_975_413# _146__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__146__23 VGND _146__a_1059_315# net4 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _147_ with the contents of sky130_fd_sc_hd__dfxtp_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__147__0 _147__a_891_413# _147__a_193_47# _147__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__147__1 _147__a_1059_315# _147__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__147__2 _147__a_466_413# _147__a_27_47# _147__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__147__3 _147__a_634_159# _147__a_27_47# _147__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__147__4 _147__a_381_47# _147__a_193_47# _147__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__147__5 VPWR _001_ _147__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__147__6 VPWR _147__a_466_413# _147__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__147__7 VGND _147__a_466_413# _147__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__147__8 _147__a_1017_47# _147__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__147__9 _147__a_1059_315# _147__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: Q w=1]]', 'g: [connection X10/g =>[signal: a_1059_315# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__147__10 cnt2[0] _147__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_561_413# w=1]]', 'g: [connection X11/g =>[signal: a_634_159# w=1]]', 's: [connection X11/s =>[signal: VPWR w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__147__11 _147__a_561_413# _147__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: a_1059_315# w=1]]', 's: [connection X12/s =>[signal: Q w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__147__12 VPWR _147__a_1059_315# cnt2[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_891_413# w=1]]', 'g: [connection X13/g =>[signal: a_27_47# w=1]]', 's: [connection X13/s =>[signal: a_1017_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__147__13 _147__a_891_413# _147__a_27_47# _147__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_634_159# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_891_413# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__147__14 _147__a_634_159# _147__a_193_47# _147__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_592_47# w=1]]', 'g: [connection X15/g =>[signal: a_634_159# w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__147__15 _147__a_592_47# _147__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_466_413# w=1]]', 'g: [connection X16/g =>[signal: a_193_47# w=1]]', 's: [connection X16/s =>[signal: a_592_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__147__16 _147__a_466_413# _147__a_193_47# _147__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: VGND w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_193_47# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__147__17 VGND _147__a_27_47# _147__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_381_47# w=1]]', 'g: [connection X18/g =>[signal: a_27_47# w=1]]', 's: [connection X18/s =>[signal: a_466_413# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__147__18 _147__a_381_47# _147__a_27_47# _147__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__147__19 _147__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_27_47# w=1]]', 'g: [connection X20/g =>[signal: CLK w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__147__20 _147__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: Q w=1]]', 'g: [connection X21/g =>[signal: a_1059_315# w=1]]', 's: [connection X21/s =>[signal: VGND w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__147__21 cnt2[0] _147__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VPWR w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__147__22 VPWR _147__a_27_47# _147__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_381_47# w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__147__23 VGND _001_ _147__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_975_413# w=1]]', 'g: [connection X24/g =>[signal: a_1059_315# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__147__24 _147__a_975_413# _147__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_1059_315# w=1]]', 's: [connection X25/s =>[signal: Q w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X__147__25 VGND _147__a_1059_315# cnt2[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _148_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__148__0 _148__a_891_413# _148__a_193_47# _148__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__148__1 _148__a_1059_315# _148__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__148__2 _148__a_466_413# _148__a_27_47# _148__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__148__3 _148__a_634_159# _148__a_27_47# _148__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__148__4 _148__a_381_47# _148__a_193_47# _148__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__148__5 VPWR _002_ _148__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__148__6 VPWR _148__a_466_413# _148__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__148__7 VGND _148__a_466_413# _148__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__148__8 _148__a_1017_47# _148__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__148__9 _148__a_1059_315# _148__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__148__10 _148__a_561_413# _148__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__148__11 VPWR _148__a_1059_315# cnt2[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__148__12 _148__a_891_413# _148__a_27_47# _148__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__148__13 _148__a_634_159# _148__a_193_47# _148__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__148__14 _148__a_592_47# _148__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__148__15 _148__a_466_413# _148__a_193_47# _148__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__148__16 VGND _148__a_27_47# _148__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__148__17 _148__a_381_47# _148__a_27_47# _148__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__148__18 _148__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__148__19 _148__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__148__20 VPWR _148__a_27_47# _148__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__148__21 VGND _002_ _148__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__148__22 _148__a_975_413# _148__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__148__23 VGND _148__a_1059_315# cnt2[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _149_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__149__0 _149__a_891_413# _149__a_193_47# _149__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__149__1 _149__a_1059_315# _149__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__149__2 _149__a_466_413# _149__a_27_47# _149__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__149__3 _149__a_634_159# _149__a_27_47# _149__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__149__4 _149__a_381_47# _149__a_193_47# _149__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__149__5 VPWR _003_ _149__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__149__6 VPWR _149__a_466_413# _149__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__149__7 VGND _149__a_466_413# _149__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__149__8 _149__a_1017_47# _149__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__149__9 _149__a_1059_315# _149__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__149__10 _149__a_561_413# _149__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__149__11 VPWR _149__a_1059_315# cnt1[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__149__12 _149__a_891_413# _149__a_27_47# _149__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__149__13 _149__a_634_159# _149__a_193_47# _149__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__149__14 _149__a_592_47# _149__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__149__15 _149__a_466_413# _149__a_193_47# _149__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__149__16 VGND _149__a_27_47# _149__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__149__17 _149__a_381_47# _149__a_27_47# _149__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__149__18 _149__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__149__19 _149__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__149__20 VPWR _149__a_27_47# _149__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__149__21 VGND _003_ _149__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__149__22 _149__a_975_413# _149__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__149__23 VGND _149__a_1059_315# cnt1[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _150_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__150__0 _150__a_891_413# _150__a_193_47# _150__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__150__1 _150__a_1059_315# _150__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__150__2 _150__a_466_413# _150__a_27_47# _150__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__150__3 _150__a_634_159# _150__a_27_47# _150__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__150__4 _150__a_381_47# _150__a_193_47# _150__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__150__5 VPWR _004_ _150__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__150__6 VPWR _150__a_466_413# _150__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__150__7 VGND _150__a_466_413# _150__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__150__8 _150__a_1017_47# _150__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__150__9 _150__a_1059_315# _150__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__150__10 _150__a_561_413# _150__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__150__11 VPWR _150__a_1059_315# cnt1[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__150__12 _150__a_891_413# _150__a_27_47# _150__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__150__13 _150__a_634_159# _150__a_193_47# _150__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__150__14 _150__a_592_47# _150__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__150__15 _150__a_466_413# _150__a_193_47# _150__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__150__16 VGND _150__a_27_47# _150__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__150__17 _150__a_381_47# _150__a_27_47# _150__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__150__18 _150__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__150__19 _150__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__150__20 VPWR _150__a_27_47# _150__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__150__21 VGND _004_ _150__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__150__22 _150__a_975_413# _150__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__150__23 VGND _150__a_1059_315# cnt1[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _151_ with the contents of sky130_fd_sc_hd__dfxtp_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__151__0 _151__a_891_413# _151__a_193_47# _151__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__151__1 _151__a_1059_315# _151__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__151__2 _151__a_466_413# _151__a_27_47# _151__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__151__3 _151__a_634_159# _151__a_27_47# _151__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__151__4 _151__a_381_47# _151__a_193_47# _151__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__151__5 VPWR _005_ _151__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__151__6 VPWR _151__a_466_413# _151__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__151__7 VGND _151__a_466_413# _151__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__151__8 _151__a_1017_47# _151__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__151__9 _151__a_1059_315# _151__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: Q w=1]]', 'g: [connection X10/g =>[signal: a_1059_315# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__151__10 cnt1[2] _151__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_561_413# w=1]]', 'g: [connection X11/g =>[signal: a_634_159# w=1]]', 's: [connection X11/s =>[signal: VPWR w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__151__11 _151__a_561_413# _151__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: a_1059_315# w=1]]', 's: [connection X12/s =>[signal: Q w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__151__12 VPWR _151__a_1059_315# cnt1[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_891_413# w=1]]', 'g: [connection X13/g =>[signal: a_27_47# w=1]]', 's: [connection X13/s =>[signal: a_1017_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__151__13 _151__a_891_413# _151__a_27_47# _151__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_634_159# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_891_413# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__151__14 _151__a_634_159# _151__a_193_47# _151__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_592_47# w=1]]', 'g: [connection X15/g =>[signal: a_634_159# w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__151__15 _151__a_592_47# _151__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_466_413# w=1]]', 'g: [connection X16/g =>[signal: a_193_47# w=1]]', 's: [connection X16/s =>[signal: a_592_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__151__16 _151__a_466_413# _151__a_193_47# _151__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: VGND w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_193_47# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__151__17 VGND _151__a_27_47# _151__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_381_47# w=1]]', 'g: [connection X18/g =>[signal: a_27_47# w=1]]', 's: [connection X18/s =>[signal: a_466_413# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__151__18 _151__a_381_47# _151__a_27_47# _151__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__151__19 _151__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_27_47# w=1]]', 'g: [connection X20/g =>[signal: CLK w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__151__20 _151__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: Q w=1]]', 'g: [connection X21/g =>[signal: a_1059_315# w=1]]', 's: [connection X21/s =>[signal: VGND w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__151__21 cnt1[2] _151__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VPWR w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__151__22 VPWR _151__a_27_47# _151__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_381_47# w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__151__23 VGND _005_ _151__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_975_413# w=1]]', 'g: [connection X24/g =>[signal: a_1059_315# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__151__24 _151__a_975_413# _151__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_1059_315# w=1]]', 's: [connection X25/s =>[signal: Q w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X__151__25 VGND _151__a_1059_315# cnt1[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _152_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__152__0 _152__a_891_413# _152__a_193_47# _152__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__152__1 _152__a_1059_315# _152__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__152__2 _152__a_466_413# _152__a_27_47# _152__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__152__3 _152__a_634_159# _152__a_27_47# _152__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__152__4 _152__a_381_47# _152__a_193_47# _152__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__152__5 VPWR _006_ _152__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__152__6 VPWR _152__a_466_413# _152__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__152__7 VGND _152__a_466_413# _152__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__152__8 _152__a_1017_47# _152__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__152__9 _152__a_1059_315# _152__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__152__10 _152__a_561_413# _152__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__152__11 VPWR _152__a_1059_315# cnt1[3] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__152__12 _152__a_891_413# _152__a_27_47# _152__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__152__13 _152__a_634_159# _152__a_193_47# _152__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__152__14 _152__a_592_47# _152__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__152__15 _152__a_466_413# _152__a_193_47# _152__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__152__16 VGND _152__a_27_47# _152__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__152__17 _152__a_381_47# _152__a_27_47# _152__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__152__18 _152__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__152__19 _152__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__152__20 VPWR _152__a_27_47# _152__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__152__21 VGND _006_ _152__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__152__22 _152__a_975_413# _152__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__152__23 VGND _152__a_1059_315# cnt1[3] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _153_ with the contents of sky130_fd_sc_hd__dfxtp_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__153__0 _153__a_891_413# _153__a_193_47# _153__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__153__1 _153__a_1059_315# _153__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__153__2 _153__a_466_413# _153__a_27_47# _153__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__153__3 _153__a_634_159# _153__a_27_47# _153__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__153__4 _153__a_381_47# _153__a_193_47# _153__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__153__5 VPWR _007_ _153__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__153__6 VPWR _153__a_466_413# _153__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__153__7 VGND _153__a_466_413# _153__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__153__8 _153__a_1017_47# _153__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__153__9 _153__a_1059_315# _153__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: Q w=1]]', 'g: [connection X10/g =>[signal: a_1059_315# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__153__10 cnt1[4] _153__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_561_413# w=1]]', 'g: [connection X11/g =>[signal: a_634_159# w=1]]', 's: [connection X11/s =>[signal: VPWR w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__153__11 _153__a_561_413# _153__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: a_1059_315# w=1]]', 's: [connection X12/s =>[signal: Q w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__153__12 VPWR _153__a_1059_315# cnt1[4] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_891_413# w=1]]', 'g: [connection X13/g =>[signal: a_27_47# w=1]]', 's: [connection X13/s =>[signal: a_1017_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__153__13 _153__a_891_413# _153__a_27_47# _153__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_634_159# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_891_413# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__153__14 _153__a_634_159# _153__a_193_47# _153__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_592_47# w=1]]', 'g: [connection X15/g =>[signal: a_634_159# w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__153__15 _153__a_592_47# _153__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_466_413# w=1]]', 'g: [connection X16/g =>[signal: a_193_47# w=1]]', 's: [connection X16/s =>[signal: a_592_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__153__16 _153__a_466_413# _153__a_193_47# _153__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: VGND w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_193_47# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__153__17 VGND _153__a_27_47# _153__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_381_47# w=1]]', 'g: [connection X18/g =>[signal: a_27_47# w=1]]', 's: [connection X18/s =>[signal: a_466_413# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__153__18 _153__a_381_47# _153__a_27_47# _153__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__153__19 _153__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_27_47# w=1]]', 'g: [connection X20/g =>[signal: CLK w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__153__20 _153__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: Q w=1]]', 'g: [connection X21/g =>[signal: a_1059_315# w=1]]', 's: [connection X21/s =>[signal: VGND w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__153__21 cnt1[4] _153__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VPWR w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__153__22 VPWR _153__a_27_47# _153__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_381_47# w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__153__23 VGND _007_ _153__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_975_413# w=1]]', 'g: [connection X24/g =>[signal: a_1059_315# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__153__24 _153__a_975_413# _153__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_1059_315# w=1]]', 's: [connection X25/s =>[signal: Q w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X__153__25 VGND _153__a_1059_315# cnt1[4] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _154_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__154__0 _154__a_891_413# _154__a_193_47# _154__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__154__1 _154__a_1059_315# _154__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__154__2 _154__a_466_413# _154__a_27_47# _154__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__154__3 _154__a_634_159# _154__a_27_47# _154__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__154__4 _154__a_381_47# _154__a_193_47# _154__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__154__5 VPWR _008_ _154__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__154__6 VPWR _154__a_466_413# _154__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__154__7 VGND _154__a_466_413# _154__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__154__8 _154__a_1017_47# _154__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__154__9 _154__a_1059_315# _154__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__154__10 _154__a_561_413# _154__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__154__11 VPWR _154__a_1059_315# cnt1[5] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__154__12 _154__a_891_413# _154__a_27_47# _154__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__154__13 _154__a_634_159# _154__a_193_47# _154__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__154__14 _154__a_592_47# _154__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__154__15 _154__a_466_413# _154__a_193_47# _154__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__154__16 VGND _154__a_27_47# _154__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__154__17 _154__a_381_47# _154__a_27_47# _154__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__154__18 _154__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__154__19 _154__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__154__20 VPWR _154__a_27_47# _154__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__154__21 VGND _008_ _154__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__154__22 _154__a_975_413# _154__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__154__23 VGND _154__a_1059_315# cnt1[5] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _155_ with the contents of sky130_fd_sc_hd__dfxtp_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__155__0 _155__a_891_413# _155__a_193_47# _155__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__155__1 _155__a_1059_315# _155__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__155__2 _155__a_466_413# _155__a_27_47# _155__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__155__3 _155__a_634_159# _155__a_27_47# _155__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__155__4 _155__a_381_47# _155__a_193_47# _155__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__155__5 VPWR _009_ _155__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__155__6 VPWR _155__a_466_413# _155__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__155__7 VGND _155__a_466_413# _155__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__155__8 _155__a_1017_47# _155__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__155__9 _155__a_1059_315# _155__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: Q w=1]]', 'g: [connection X10/g =>[signal: a_1059_315# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__155__10 cnt3[0] _155__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_561_413# w=1]]', 'g: [connection X11/g =>[signal: a_634_159# w=1]]', 's: [connection X11/s =>[signal: VPWR w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__155__11 _155__a_561_413# _155__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: a_1059_315# w=1]]', 's: [connection X12/s =>[signal: Q w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__155__12 VPWR _155__a_1059_315# cnt3[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_891_413# w=1]]', 'g: [connection X13/g =>[signal: a_27_47# w=1]]', 's: [connection X13/s =>[signal: a_1017_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__155__13 _155__a_891_413# _155__a_27_47# _155__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_634_159# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_891_413# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__155__14 _155__a_634_159# _155__a_193_47# _155__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_592_47# w=1]]', 'g: [connection X15/g =>[signal: a_634_159# w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__155__15 _155__a_592_47# _155__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_466_413# w=1]]', 'g: [connection X16/g =>[signal: a_193_47# w=1]]', 's: [connection X16/s =>[signal: a_592_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__155__16 _155__a_466_413# _155__a_193_47# _155__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: VGND w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_193_47# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__155__17 VGND _155__a_27_47# _155__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_381_47# w=1]]', 'g: [connection X18/g =>[signal: a_27_47# w=1]]', 's: [connection X18/s =>[signal: a_466_413# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__155__18 _155__a_381_47# _155__a_27_47# _155__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__155__19 _155__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_27_47# w=1]]', 'g: [connection X20/g =>[signal: CLK w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__155__20 _155__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: Q w=1]]', 'g: [connection X21/g =>[signal: a_1059_315# w=1]]', 's: [connection X21/s =>[signal: VGND w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__155__21 cnt3[0] _155__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VPWR w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__155__22 VPWR _155__a_27_47# _155__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_381_47# w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__155__23 VGND _009_ _155__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_975_413# w=1]]', 'g: [connection X24/g =>[signal: a_1059_315# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__155__24 _155__a_975_413# _155__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_1059_315# w=1]]', 's: [connection X25/s =>[signal: Q w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X__155__25 VGND _155__a_1059_315# cnt3[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _156_ with the contents of sky130_fd_sc_hd__dfxtp_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__156__0 _156__a_891_413# _156__a_193_47# _156__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__156__1 _156__a_1059_315# _156__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__156__2 _156__a_466_413# _156__a_27_47# _156__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__156__3 _156__a_634_159# _156__a_27_47# _156__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__156__4 _156__a_381_47# _156__a_193_47# _156__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__156__5 VPWR _010_ _156__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__156__6 VPWR _156__a_466_413# _156__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__156__7 VGND _156__a_466_413# _156__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__156__8 _156__a_1017_47# _156__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__156__9 _156__a_1059_315# _156__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: Q w=1]]', 'g: [connection X10/g =>[signal: a_1059_315# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__156__10 cnt3[1] _156__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_561_413# w=1]]', 'g: [connection X11/g =>[signal: a_634_159# w=1]]', 's: [connection X11/s =>[signal: VPWR w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__156__11 _156__a_561_413# _156__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: a_1059_315# w=1]]', 's: [connection X12/s =>[signal: Q w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__156__12 VPWR _156__a_1059_315# cnt3[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_891_413# w=1]]', 'g: [connection X13/g =>[signal: a_27_47# w=1]]', 's: [connection X13/s =>[signal: a_1017_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__156__13 _156__a_891_413# _156__a_27_47# _156__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_634_159# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_891_413# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__156__14 _156__a_634_159# _156__a_193_47# _156__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_592_47# w=1]]', 'g: [connection X15/g =>[signal: a_634_159# w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__156__15 _156__a_592_47# _156__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_466_413# w=1]]', 'g: [connection X16/g =>[signal: a_193_47# w=1]]', 's: [connection X16/s =>[signal: a_592_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__156__16 _156__a_466_413# _156__a_193_47# _156__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: VGND w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_193_47# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__156__17 VGND _156__a_27_47# _156__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_381_47# w=1]]', 'g: [connection X18/g =>[signal: a_27_47# w=1]]', 's: [connection X18/s =>[signal: a_466_413# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__156__18 _156__a_381_47# _156__a_27_47# _156__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__156__19 _156__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_27_47# w=1]]', 'g: [connection X20/g =>[signal: CLK w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__156__20 _156__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: Q w=1]]', 'g: [connection X21/g =>[signal: a_1059_315# w=1]]', 's: [connection X21/s =>[signal: VGND w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__156__21 cnt3[1] _156__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VPWR w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__156__22 VPWR _156__a_27_47# _156__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_381_47# w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__156__23 VGND _010_ _156__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_975_413# w=1]]', 'g: [connection X24/g =>[signal: a_1059_315# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__156__24 _156__a_975_413# _156__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_1059_315# w=1]]', 's: [connection X25/s =>[signal: Q w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X__156__25 VGND _156__a_1059_315# cnt3[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _157_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__157__0 _157__a_891_413# _157__a_193_47# _157__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__157__1 _157__a_1059_315# _157__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__157__2 _157__a_466_413# _157__a_27_47# _157__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__157__3 _157__a_634_159# _157__a_27_47# _157__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__157__4 _157__a_381_47# _157__a_193_47# _157__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__157__5 VPWR _011_ _157__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__157__6 VPWR _157__a_466_413# _157__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__157__7 VGND _157__a_466_413# _157__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__157__8 _157__a_1017_47# _157__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__157__9 _157__a_1059_315# _157__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__157__10 _157__a_561_413# _157__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__157__11 VPWR _157__a_1059_315# cnt3[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__157__12 _157__a_891_413# _157__a_27_47# _157__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__157__13 _157__a_634_159# _157__a_193_47# _157__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__157__14 _157__a_592_47# _157__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__157__15 _157__a_466_413# _157__a_193_47# _157__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__157__16 VGND _157__a_27_47# _157__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__157__17 _157__a_381_47# _157__a_27_47# _157__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__157__18 _157__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__157__19 _157__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__157__20 VPWR _157__a_27_47# _157__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__157__21 VGND _011_ _157__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__157__22 _157__a_975_413# _157__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__157__23 VGND _157__a_1059_315# cnt3[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _158_ with the contents of sky130_fd_sc_hd__dfxtp_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__158__0 _158__a_891_413# _158__a_193_47# _158__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__158__1 _158__a_1059_315# _158__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__158__2 _158__a_466_413# _158__a_27_47# _158__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__158__3 _158__a_634_159# _158__a_27_47# _158__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__158__4 _158__a_381_47# _158__a_193_47# _158__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__158__5 VPWR _012_ _158__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__158__6 VPWR _158__a_466_413# _158__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__158__7 VGND _158__a_466_413# _158__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__158__8 _158__a_1017_47# _158__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__158__9 _158__a_1059_315# _158__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: Q w=1]]', 'g: [connection X10/g =>[signal: a_1059_315# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__158__10 cnt4[0] _158__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_561_413# w=1]]', 'g: [connection X11/g =>[signal: a_634_159# w=1]]', 's: [connection X11/s =>[signal: VPWR w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__158__11 _158__a_561_413# _158__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: a_1059_315# w=1]]', 's: [connection X12/s =>[signal: Q w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__158__12 VPWR _158__a_1059_315# cnt4[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_891_413# w=1]]', 'g: [connection X13/g =>[signal: a_27_47# w=1]]', 's: [connection X13/s =>[signal: a_1017_47# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__158__13 _158__a_891_413# _158__a_27_47# _158__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_634_159# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_891_413# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__158__14 _158__a_634_159# _158__a_193_47# _158__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_592_47# w=1]]', 'g: [connection X15/g =>[signal: a_634_159# w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__158__15 _158__a_592_47# _158__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_466_413# w=1]]', 'g: [connection X16/g =>[signal: a_193_47# w=1]]', 's: [connection X16/s =>[signal: a_592_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__158__16 _158__a_466_413# _158__a_193_47# _158__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: VGND w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_193_47# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__158__17 VGND _158__a_27_47# _158__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_381_47# w=1]]', 'g: [connection X18/g =>[signal: a_27_47# w=1]]', 's: [connection X18/s =>[signal: a_466_413# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__158__18 _158__a_381_47# _158__a_27_47# _158__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__158__19 _158__a_27_47# clknet_1_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_27_47# w=1]]', 'g: [connection X20/g =>[signal: CLK w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__158__20 _158__a_27_47# clknet_1_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: Q w=1]]', 'g: [connection X21/g =>[signal: a_1059_315# w=1]]', 's: [connection X21/s =>[signal: VGND w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__158__21 cnt4[0] _158__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VPWR w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__158__22 VPWR _158__a_27_47# _158__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_381_47# w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__158__23 VGND _012_ _158__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_975_413# w=1]]', 'g: [connection X24/g =>[signal: a_1059_315# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__158__24 _158__a_975_413# _158__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_1059_315# w=1]]', 's: [connection X25/s =>[signal: Q w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X__158__25 VGND _158__a_1059_315# cnt4[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _159_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__159__0 _159__a_891_413# _159__a_193_47# _159__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__159__1 _159__a_1059_315# _159__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__159__2 _159__a_466_413# _159__a_27_47# _159__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__159__3 _159__a_634_159# _159__a_27_47# _159__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__159__4 _159__a_381_47# _159__a_193_47# _159__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__159__5 VPWR _013_ _159__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__159__6 VPWR _159__a_466_413# _159__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__159__7 VGND _159__a_466_413# _159__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__159__8 _159__a_1017_47# _159__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__159__9 _159__a_1059_315# _159__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__159__10 _159__a_561_413# _159__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__159__11 VPWR _159__a_1059_315# cnt4[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__159__12 _159__a_891_413# _159__a_27_47# _159__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__159__13 _159__a_634_159# _159__a_193_47# _159__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__159__14 _159__a_592_47# _159__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__159__15 _159__a_466_413# _159__a_193_47# _159__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__159__16 VGND _159__a_27_47# _159__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__159__17 _159__a_381_47# _159__a_27_47# _159__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__159__18 _159__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__159__19 _159__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__159__20 VPWR _159__a_27_47# _159__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__159__21 VGND _013_ _159__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__159__22 _159__a_975_413# _159__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__159__23 VGND _159__a_1059_315# cnt4[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _160_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__160__0 _160__a_891_413# _160__a_193_47# _160__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__160__1 _160__a_1059_315# _160__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__160__2 _160__a_466_413# _160__a_27_47# _160__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__160__3 _160__a_634_159# _160__a_27_47# _160__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__160__4 _160__a_381_47# _160__a_193_47# _160__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__160__5 VPWR _014_ _160__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__160__6 VPWR _160__a_466_413# _160__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__160__7 VGND _160__a_466_413# _160__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__160__8 _160__a_1017_47# _160__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__160__9 _160__a_1059_315# _160__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__160__10 _160__a_561_413# _160__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__160__11 VPWR _160__a_1059_315# cnt4[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__160__12 _160__a_891_413# _160__a_27_47# _160__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__160__13 _160__a_634_159# _160__a_193_47# _160__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__160__14 _160__a_592_47# _160__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__160__15 _160__a_466_413# _160__a_193_47# _160__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__160__16 VGND _160__a_27_47# _160__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__160__17 _160__a_381_47# _160__a_27_47# _160__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__160__18 _160__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__160__19 _160__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__160__20 VPWR _160__a_27_47# _160__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__160__21 VGND _014_ _160__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__160__22 _160__a_975_413# _160__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__160__23 VGND _160__a_1059_315# cnt4[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _161_ with the contents of sky130_fd_sc_hd__dfxtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_891_413# w=1]]', 'g: [connection X0/g =>[signal: a_193_47# w=1]]', 's: [connection X0/s =>[signal: a_975_413# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__161__0 _161__a_891_413# _161__a_193_47# _161__a_975_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1059_315# w=1]]', 'g: [connection X1/g =>[signal: a_891_413# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__161__1 _161__a_1059_315# _161__a_891_413# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_466_413# w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: a_561_413# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__161__2 _161__a_466_413# _161__a_27_47# _161__a_561_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_634_159# w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: a_891_413# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__161__3 _161__a_634_159# _161__a_27_47# _161__a_891_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_381_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_466_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__161__4 _161__a_381_47# _161__a_193_47# _161__a_466_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: D w=1]]', 's: [connection X5/s =>[signal: a_381_47# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__161__5 VPWR _015_ _161__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '750000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: a_466_413# w=1]]', 's: [connection X6/s =>[signal: a_634_159# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__161__6 VPWR _161__a_466_413# _161__a_634_159# VPWR sky130_fd_pr__pfet_01v8_hvt W=750000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: a_466_413# w=1]]', 's: [connection X7/s =>[signal: a_634_159# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__161__7 VGND _161__a_466_413# _161__a_634_159# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_1017_47# w=1]]', 'g: [connection X8/g =>[signal: a_1059_315# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__161__8 _161__a_1017_47# _161__a_1059_315# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_1059_315# w=1]]', 'g: [connection X9/g =>[signal: a_891_413# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__161__9 _161__a_1059_315# _161__a_891_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_561_413# w=1]]', 'g: [connection X10/g =>[signal: a_634_159# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__161__10 _161__a_561_413# _161__a_634_159# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_1059_315# w=1]]', 's: [connection X11/s =>[signal: Q w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__161__11 VPWR _161__a_1059_315# cnt4[3] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_891_413# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_1017_47# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__161__12 _161__a_891_413# _161__a_27_47# _161__a_1017_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_634_159# w=1]]', 'g: [connection X13/g =>[signal: a_193_47# w=1]]', 's: [connection X13/s =>[signal: a_891_413# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__161__13 _161__a_634_159# _161__a_193_47# _161__a_891_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_592_47# w=1]]', 'g: [connection X14/g =>[signal: a_634_159# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__161__14 _161__a_592_47# _161__a_634_159# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_466_413# w=1]]', 'g: [connection X15/g =>[signal: a_193_47# w=1]]', 's: [connection X15/s =>[signal: a_592_47# w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__161__15 _161__a_466_413# _161__a_193_47# _161__a_592_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__161__16 VGND _161__a_27_47# _161__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_381_47# w=1]]', 'g: [connection X17/g =>[signal: a_27_47# w=1]]', 's: [connection X17/s =>[signal: a_466_413# w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__161__17 _161__a_381_47# _161__a_27_47# _161__a_466_413# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VGND w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__161__18 _161__a_27_47# clknet_1_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VPWR w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__161__19 _161__a_27_47# clknet_1_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__161__20 VPWR _161__a_27_47# _161__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VGND w=1]]', 'g: [connection X21/g =>[signal: D w=1]]', 's: [connection X21/s =>[signal: a_381_47# w=1]]', 'b: [connection X21/b =>[signal: VNB w=1]]']]
X__161__21 VGND _015_ _161__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: a_975_413# w=1]]', 'g: [connection X22/g =>[signal: a_1059_315# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__161__22 _161__a_975_413# _161__a_1059_315# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X23 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VGND w=1]]', 'g: [connection X23/g =>[signal: a_1059_315# w=1]]', 's: [connection X23/s =>[signal: Q w=1]]', 'b: [connection X23/b =>[signal: VNB w=1]]']]
X__161__23 VGND _161__a_1059_315# cnt4[3] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing clkbuf_0_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_0 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_1 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_2 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_3 clkbuf_0_clk_a_110_47# clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_4 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_5 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_6 clkbuf_0_clk_a_110_47# clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_7 VPWR clk clkbuf_0_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_8 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_9 VGND clk clkbuf_0_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_10 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_11 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_12 clkbuf_0_clk_a_110_47# clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_13 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_14 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_15 VPWR clk clkbuf_0_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_16 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_17 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_18 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_19 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_20 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_21 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_22 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_23 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_24 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_25 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_26 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_27 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_28 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_29 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_30 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_31 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_32 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_33 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_34 clkbuf_0_clk_a_110_47# clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_35 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_36 VGND clk clkbuf_0_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_37 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_38 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_39 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_1_0__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_0 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_1 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_2 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_3 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_4 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_5 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_6 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_7 VPWR clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_8 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_9 VGND clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_10 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_11 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_12 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_13 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_14 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_15 VPWR clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_16 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_17 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_18 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_19 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_20 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_21 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_22 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_23 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_24 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_25 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_26 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_27 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_28 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_29 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_30 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_31 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_32 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_33 clknet_1_0__leaf_clk clkbuf_1_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_34 clkbuf_1_0__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_35 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_36 VGND clknet_0_clk clkbuf_1_0__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clk_37 VPWR clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_38 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clk_39 VGND clkbuf_1_0__f_clk_a_110_47# clknet_1_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_1_1__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_0 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_1 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_2 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_3 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_4 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_5 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_6 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_7 VPWR clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_8 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_9 VGND clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_10 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_11 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_12 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_13 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_14 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_15 VPWR clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_16 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_17 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_18 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_19 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_20 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_21 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_22 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_23 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_24 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_25 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_26 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_27 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_28 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_29 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_30 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_31 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_32 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_33 clknet_1_1__leaf_clk clkbuf_1_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_34 clkbuf_1_1__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_35 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_36 VGND clknet_0_clk clkbuf_1_1__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clk_37 VPWR clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_38 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clk_39 VGND clkbuf_1_1__f_clk_a_110_47# clknet_1_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing input1 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input1_0 VGND reset input1_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input1_1 net1 input1_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input1_2 net1 input1_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input1_3 VPWR reset input1_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input2 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input2_0 VGND sel.0 input2_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input2_1 net2 input2_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input2_2 net2 input2_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input2_3 VPWR sel.0 input2_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input3 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input3_0 VGND sel.1 input3_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input3_1 net3 input3_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input3_2 net3 input3_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input3_3 VPWR sel.1 input3_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing output4 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output4_0 clkout output4_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output4_1 output4_a_27_47# net4 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output4_2 VGND output4_a_27_47# clkout VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output4_3 clkout output4_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output4_4 VPWR output4_a_27_47# clkout VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output4_5 output4_a_27_47# net4 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

.ENDS
